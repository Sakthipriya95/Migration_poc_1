ASAP2_VERSION 1 4
/begin PROJECT MED1734_Flx_G1 "MEDC17_Core"
/begin HEADER "" VERSION "MED1734_Flx_01" PROJECT_NO MED1734_Flx_G1 /end HEADER
/begin MODULE DIM ""
/begin MOD_COMMON "" BYTE_ORDER MSB_LAST ALIGNMENT_BYTE 1 ALIGNMENT_WORD 2 ALIGNMENT_LONG 4 ALIGNMENT_FLOAT32_IEEE 4 /end MOD_COMMON
/begin MEASUREMENT DFC_b.TST_IgnClPsShCirGnd3 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AE5F /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_IgnClPsShCirGnd4 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AE60 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_IgnClPsShCirGnd5 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AE61 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_IgnClPsShCirGnd6 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AE62 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_IgnClPsShCirGnd7 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AE63 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_KnDetSens1PortAMax "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AE64 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_KnDetSens1PortAMin "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AE65 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_KnDetSens1PortBMax "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AE66 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_KnDetSens1PortBMin "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AE67 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_KnDetSens2PortAMax "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AE68 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_KnDetSens2PortAMin "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AE69 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_KnDetSens2PortBMax "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AE6A /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_KnDetSens2PortBMin "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AE6B /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_KnDetSens3PortAMax "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AE6C /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_KnDetSens3PortAMin "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AE6D /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_KnDetSens3PortBMax "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AE6E /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_KnDetSens3PortBMin "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AE6F /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_KnDetSens4PortAMax "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AE70 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_KnDetSens4PortAMin "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AE71 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_KnDetSens4PortBMax "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AE72 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_KnDetSens4PortBMin "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AE73 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_MfPsNonPlausible "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AE74 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_MfPsNonPlausible2 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AE75 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_MfPsOpenLoad "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AE76 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_MfPsOpenLoad2 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AE77 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_MfPsShCirBattLowSide "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AE78 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_MfPsShCirBattLowSide2 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AE79 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_MfPsShCirGndLowSide "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AE7A /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_MfPsShCirGndLowSide2 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AE7B /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_DevLibBattUHi "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AE7C /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_DevLibBattULo "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AE7D /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_DSMDummy "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AE7E /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_EEPEraseErr "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AE7F /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_EEPRdErr "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AE80 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_EEPWrErr "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AE81 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_EV1max "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AE82 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_EV1min "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AE83 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_EV1sig "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AE84 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_EV2max "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AE85 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_EV2min "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AE86 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_EV2sig "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AE87 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_EV3max "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AE88 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_EV3min "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AE89 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_EV3sig "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AE8A /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_EV4max "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AE8B /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_EV4min "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AE8C /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_EV4sig "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AE8D /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_EV5max "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AE8E /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_EV5min "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AE8F /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_EV5sig "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AE90 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_EV6max "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AE91 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_EV6min "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AE92 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_EV6sig "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AE93 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_EV7max "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AE94 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_EV7min "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AE95 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_EV7sig "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AE96 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_EV8max "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AE97 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_EV8min "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AE98 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_EV8sig "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AE99 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_EpmCaSI1ErrSig "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AE9A /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_EpmCaSI1NoSigMax "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AE9B /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_EpmCaSI1NoSigMin "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AE9C /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_EpmCaSI1OfsErr "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AE9D /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_EpmCaSI2ErrSig "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AE9E /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_EpmCaSI2NoSigMax "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AE9F /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_EpmCaSI2NoSigMin "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AEA0 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_EpmCaSI2OfsErr "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AEA1 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_EpmCaSO1ErrSig "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AEA2 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_EpmCaSO1NoSigMax "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AEA3 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_EpmCaSO1NoSigMin "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AEA4 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_EpmCaSO1OfsErr "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AEA5 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_EpmCaSO2ErrSig "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AEA6 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_EpmCaSO2NoSigMax "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AEA7 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_EpmCaSO2NoSigMin "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AEA8 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_EpmCaSO2OfsErr "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AEA9 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_EpmCrSDGI "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AEAA /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_EpmCrSErrSig "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AEAB /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_EpmCrSNoSig "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AEAC /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_HDEVH_MAX_0 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AEAD /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_HDEVH_MAX_1 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AEAE /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_HDEVH_MAX_2 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AEAF /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_HDEVH_MAX_3 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AEB0 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_HDEVH_MAX_4 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AEB1 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_HDEVH_MAX_5 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AEB2 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_HDEVH_MAX_6 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AEB3 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_HDEVH_MAX_7 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AEB4 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_HDEVH_MIN_0 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AEB5 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_HDEVH_MIN_1 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AEB6 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_HDEVH_MIN_2 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AEB7 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_HDEVH_MIN_3 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AEB8 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_HDEVH_MIN_4 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AEB9 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_HDEVH_MIN_5 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AEBA /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_HDEVH_MIN_6 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AEBB /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_HDEVH_MIN_7 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AEBC /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_HDEVH_NPL_0 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AEBD /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_HDEVH_NPL_1 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AEBE /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_HDEVH_NPL_2 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AEBF /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_HDEVH_NPL_3 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AEC0 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_HDEVH_NPL_4 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AEC1 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_HDEVH_NPL_5 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AEC2 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_HDEVH_NPL_6 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AEC3 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_HDEVH_NPL_7 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AEC4 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_HDEVL_MAX_0 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AEC5 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_HDEVL_MAX_1 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AEC6 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_HDEVL_MAX_2 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AEC7 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_HDEVL_MAX_3 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AEC8 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_HDEVL_MAX_4 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AEC9 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_HDEVL_MAX_5 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AECA /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_HDEVL_MAX_6 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AECB /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_HDEVL_MAX_7 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AECC /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_HDEVL_MIN_0 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AECD /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_HDEVL_MIN_1 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AECE /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_HDEVL_MIN_2 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AECF /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_HDEVL_MIN_3 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AED0 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_HDEVL_MIN_4 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AED1 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_HDEVL_MIN_5 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AED2 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_HDEVL_MIN_6 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AED3 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_HDEVL_MIN_7 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AED4 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_HDEVL_NPL_0 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AED5 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_HDEVL_NPL_1 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AED6 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_HDEVL_NPL_2 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AED7 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_HDEVL_NPL_3 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AED8 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_HDEVL_NPL_4 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AED9 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_HDEVL_NPL_5 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AEDA /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_HDEVL_NPL_6 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AEDB /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_HDEVL_NPL_7 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AEDC /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_HDEVL_SIG_0 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AEDD /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_HDEVL_SIG_1 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AEDE /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_HDEVL_SIG_2 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AEDF /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_HDEVL_SIG_3 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AEE0 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_HDEVL_SIG_4 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AEE1 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_HDEVL_SIG_5 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AEE2 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_HDEVL_SIG_6 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AEE3 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_HDEVL_SIG_7 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AEE4 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_HSFE2max "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AEE5 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_HSFE2min "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AEE6 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_HSFE2sig "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AEE7 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_HSFEmax "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AEE8 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_HSFEmin "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AEE9 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_HSFEsig "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AEEA /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_HSHE2max "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AEEB /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_HSHE2min "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AEEC /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_HSHE2sig "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AEED /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_HSHEmax "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AEEE /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_HSHEmin "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AEEF /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_HSHEsig "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AEF0 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_HSVE2max "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AEF1 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_HSVE2maxLSF "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AEF2 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_HSVE2min "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AEF3 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_HSVE2minLSF "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AEF4 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_HSVE2sig "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AEF5 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_HSVE2sigLSF "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AEF6 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_HSVEmax "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AEF7 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_HSVEmaxLSF "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AEF8 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_HSVEmin "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AEF9 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_HSVEminLSF "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AEFA /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_HSVEsig "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AEFB /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_HSVEsigLSF "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AEFC /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_ICLSU2max "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AEFD /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_ICLSU2min "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AEFE /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_ICLSU2npl "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AEFF /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_ICLSU2sig "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AF00 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_ICLSUmax "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AF01 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_ICLSUmin "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AF02 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_ICLSUnpl "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AF03 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_ICLSUsig "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AF04 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_LSF2max "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AF05 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_LSF2min "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AF06 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_LSF2npl "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AF07 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_LSF2sig "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AF08 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_LSFmax "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AF09 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_LSFmin "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AF0A /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_LSFnpl "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AF0B /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_LSFsig "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AF0C /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_LSH2max "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AF0D /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_LSH2min "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AF0E /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_LSH2npl "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AF0F /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_LSH2sig "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AF10 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_LSHmax "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AF11 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_LSHmin "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AF12 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_LSHnpl "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AF13 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_LSHsig "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AF14 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_LSUIA2sig "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AF15 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_LSUIAsig "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AF16 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_LSUIP2max "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AF17 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_LSUIP2npl "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AF18 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_LSUIP2sig "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AF19 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_LSUIPmax "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AF1A /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_LSUIPnpl "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AF1B /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_LSUIPsig "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AF1C /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_LSUKS2max "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AF1D /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_LSUKS2min "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AF1E /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_LSUKSmax "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AF1F /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_LSUKSmin "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AF20 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_LSUUN2sig "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AF21 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_LSUUNsig "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AF22 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_LSUVM2sig "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AF23 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_LSUVMsig "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AF24 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_LSV2max "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AF25 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_LSV2min "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AF26 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_LSV2npl "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AF27 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_LSV2sig "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AF28 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_LSVmax "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AF29 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_LSVmin "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AF2A /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_LSVnpl "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AF2B /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_LSVsig "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AF2C /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_MD00max "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AF2D /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_MD00min "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AF2E /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_MD00npl "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AF2F /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_MD01max "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AF30 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_MD01min "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AF31 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_MD01npl "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AF32 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_MD02max "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AF33 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_MD02min "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AF34 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_MD02npl "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AF35 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_MD03max "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AF36 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_MD03min "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AF37 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_MD03npl "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AF38 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_MD04max "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AF39 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_MD04min "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AF3A /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_MD04npl "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AF3B /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_MD05max "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AF3C /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_MD05min "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AF3D /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_MD05npl "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AF3E /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_MD06max "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AF3F /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_MD06min "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AF40 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_MD06npl "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AF41 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_MD07max "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AF42 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_MD07min "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AF43 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_MD07npl "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AF44 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_MDmax "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AF45 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_MDmin "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AF46 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_MDnpl "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AF47 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_MRlyErlyOpng "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AF48 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_MRlyStk "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AF49 /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_PLLSUmax "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AF4A /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_PLLSUmin "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AF4B /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_PLLSUnpl "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AF4C /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_PLLSUsig "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AF4D /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_SWReset_0 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AF4E /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_SWReset_1 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AF4F /end MEASUREMENT
/begin MEASUREMENT DFC_b.TST_SWReset_2 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD001AF50 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_BusDiagBusOffErrPasNodeA "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001ADA9 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_BusDiagBusOffErrPasNodeB "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001ADAA /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_BusDiagBusOffErrPasNodeC "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001ADAB /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_BusDiagBusOffErrPasNodeD "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001ADAC /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_BusDiagBusOffNodeA "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001ADAD /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_BusDiagBusOffNodeB "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001ADAE /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_BusDiagBusOffNodeC "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001ADAF /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_BusDiagBusOffNodeD "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001ADB0 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_ComCANG1_HDL0TO "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001ADB1 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_ComCANG1_HDL10TO "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001ADB2 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_ComCANG1_HDL11TO "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001ADB3 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_ComCANG1_HDL12TO "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001ADB4 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_ComCANG1_HDL13TO "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001ADB5 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_ComCANG1_HDL14TO "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001ADB6 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_ComCANG1_HDL15TO "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001ADB7 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_ComCANG1_HDL16TO "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001ADB8 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_ComCANG1_HDL17TO "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001ADB9 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_ComCANG1_HDL18TO "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001ADBA /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_ComCANG1_HDL19TO "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001ADBB /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_ComCANG1_HDL1TO "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001ADBC /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_ComCANG1_HDL20TO "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001ADBD /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_ComCANG1_HDL21TO "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001ADBE /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_ComCANG1_HDL22TO "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001ADBF /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_ComCANG1_HDL23TO "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001ADC0 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_ComCANG1_HDL24TO "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001ADC1 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_ComCANG1_HDL2TO "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001ADC2 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_ComCANG1_HDL3TO "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001ADC3 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_ComCANG1_HDL4TO "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001ADC4 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_ComCANG1_HDL5TO "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001ADC5 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_ComCANG1_HDL6TO "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001ADC6 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_ComCANG1_HDL7TO "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001ADC7 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_ComCANG1_HDL8TO "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001ADC8 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_ComCANG1_HDL9TO "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001ADC9 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_ComCANG2_HDL0TO "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001ADCA /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_ComCANG2_HDL10TO "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001ADCB /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_ComCANG2_HDL11TO "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001ADCC /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_ComCANG2_HDL12TO "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001ADCD /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_ComCANG2_HDL13TO "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001ADCE /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_ComCANG2_HDL14TO "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001ADCF /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_ComCANG2_HDL15TO "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001ADD0 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_ComCANG2_HDL16TO "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001ADD1 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_ComCANG2_HDL17TO "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001ADD2 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_ComCANG2_HDL18TO "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001ADD3 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_ComCANG2_HDL19TO "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001ADD4 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_ComCANG2_HDL1TO "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001ADD5 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_ComCANG2_HDL20TO "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001ADD6 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_ComCANG2_HDL21TO "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001ADD7 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_ComCANG2_HDL22TO "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001ADD8 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_ComCANG2_HDL23TO "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001ADD9 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_ComCANG2_HDL24TO "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001ADDA /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_ComCANG2_HDL2TO "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001ADDB /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_ComCANG2_HDL3TO "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001ADDC /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_ComCANG2_HDL4TO "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001ADDD /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_ComCANG2_HDL5TO "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001ADDE /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_ComCANG2_HDL6TO "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001ADDF /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_ComCANG2_HDL7TO "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001ADE0 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_ComCANG2_HDL8TO "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001ADE1 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_ComCANG2_HDL9TO "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001ADE2 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_ComCANG3_HDL0TO "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001ADE3 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_ComCANG3_HDL10TO "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001ADE4 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_ComCANG3_HDL11TO "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001ADE5 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_ComCANG3_HDL12TO "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001ADE6 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_ComCANG3_HDL13TO "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001ADE7 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_ComCANG3_HDL14TO "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001ADE8 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_ComCANG3_HDL15TO "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001ADE9 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_ComCANG3_HDL16TO "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001ADEA /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_ComCANG3_HDL17TO "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001ADEB /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_ComCANG3_HDL18TO "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001ADEC /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_ComCANG3_HDL19TO "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001ADED /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_ComCANG3_HDL1TO "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001ADEE /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_ComCANG3_HDL20TO "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001ADEF /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_ComCANG3_HDL21TO "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001ADF0 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_ComCANG3_HDL22TO "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001ADF1 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_ComCANG3_HDL23TO "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001ADF2 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_ComCANG3_HDL24TO "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001ADF3 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_ComCANG3_HDL2TO "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001ADF4 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_ComCANG3_HDL3TO "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001ADF5 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_ComCANG3_HDL4TO "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001ADF6 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_ComCANG3_HDL5TO "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001ADF7 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_ComCANG3_HDL6TO "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001ADF8 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_ComCANG3_HDL7TO "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001ADF9 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_ComCANG3_HDL8TO "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001ADFA /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_ComCANG3_HDL9TO "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001ADFB /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_ComCANG4_HDL0TO "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001ADFC /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_ComCANG4_HDL10TO "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001ADFD /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_ComCANG4_HDL11TO "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001ADFE /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_ComCANG4_HDL12TO "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001ADFF /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_ComCANG4_HDL13TO "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE00 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_ComCANG4_HDL14TO "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE01 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_ComCANG4_HDL15TO "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE02 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_ComCANG4_HDL16TO "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE03 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_ComCANG4_HDL17TO "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE04 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_ComCANG4_HDL18TO "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE05 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_ComCANG4_HDL19TO "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE06 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_ComCANG4_HDL1TO "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE07 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_ComCANG4_HDL20TO "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE08 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_ComCANG4_HDL21TO "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE09 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_ComCANG4_HDL22TO "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE0A /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_ComCANG4_HDL23TO "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE0B /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_ComCANG4_HDL24TO "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE0C /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_ComCANG4_HDL2TO "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE0D /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_ComCANG4_HDL3TO "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE0E /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_ComCANG4_HDL4TO "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE0F /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_ComCANG4_HDL5TO "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE10 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_ComCANG4_HDL6TO "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE11 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_ComCANG4_HDL7TO "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE12 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_ComCANG4_HDL8TO "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE13 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_ComCANG4_HDL9TO "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE14 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_Cy150SpiCom "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE15 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_Cy320SpiCom "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE16 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_MonUMaxSupply1 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE17 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_MonUMaxSupply2 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE18 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_MonUMaxSupply3 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE19 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_MonUMinSupply1 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE1A /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_MonUMinSupply2 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE1B /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_MonUMinSupply3 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE1C /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_SSpMon1 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE1D /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_SSpMon1OV "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE1E /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_SSpMon1UV "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE1F /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_SSpMon2 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE20 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_SSpMon2OV "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE21 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_SSpMon2UV "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE22 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_SSpMon3 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE23 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_SSpMon3OV "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE24 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_SSpMon3UV "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE25 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_HDEVK_MIN_0 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE26 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_HDEVK_MIN_1 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE27 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_HDEVK_NPL_0 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE28 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_HDEVK_NPL_1 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE29 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_HDEVK_SIG_0 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE2A /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_HDEVK_SIG_1 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE2B /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_IgnClPsClOpen0 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE2C /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_IgnClPsClOpen1 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE2D /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_IgnClPsClOpen2 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE2E /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_IgnClPsClOpen3 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE2F /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_IgnClPsClOpen4 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE30 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_IgnClPsClOpen5 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE31 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_IgnClPsClOpen6 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE32 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_IgnClPsClOpen7 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE33 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_IgnClPsClShCir0 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE34 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_IgnClPsClShCir1 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE35 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_IgnClPsClShCir2 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE36 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_IgnClPsClShCir3 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE37 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_IgnClPsClShCir4 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE38 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_IgnClPsClShCir5 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE39 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_IgnClPsClShCir6 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE3A /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_IgnClPsClShCir7 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE3B /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_IgnClPsClUnExpt0 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE3C /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_IgnClPsClUnExpt1 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE3D /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_IgnClPsClUnExpt2 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE3E /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_IgnClPsClUnExpt3 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE3F /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_IgnClPsClUnExpt4 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE40 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_IgnClPsClUnExpt5 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE41 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_IgnClPsClUnExpt6 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE42 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_IgnClPsClUnExpt7 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE43 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_IgnClPsDevIdentErr1 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE44 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_IgnClPsDevIdentErr2 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE45 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_IgnClPsDevInitErr1 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE46 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_IgnClPsDevInitErr2 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE47 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_IgnClPsDevOscErr1 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE48 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_IgnClPsDevOscErr2 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE49 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_IgnClPsDevSpiErr1 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE4A /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_IgnClPsDevSpiErr2 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE4B /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_IgnClPsOpenLoad0 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE4C /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_IgnClPsOpenLoad1 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE4D /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_IgnClPsOpenLoad2 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE4E /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_IgnClPsOpenLoad3 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE4F /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_IgnClPsOpenLoad4 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE50 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_IgnClPsOpenLoad5 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE51 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_IgnClPsOpenLoad6 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE52 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_IgnClPsOpenLoad7 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE53 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_IgnClPsShCirBatt0 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE54 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_IgnClPsShCirBatt1 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE55 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_IgnClPsShCirBatt2 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE56 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_IgnClPsShCirBatt3 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE57 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_IgnClPsShCirBatt4 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE58 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_IgnClPsShCirBatt5 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE59 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_IgnClPsShCirBatt6 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE5A /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_IgnClPsShCirBatt7 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE5B /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_IgnClPsShCirGnd0 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE5C /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_IgnClPsShCirGnd1 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE5D /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_IgnClPsShCirGnd2 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE5E /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_IgnClPsShCirGnd3 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE5F /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_IgnClPsShCirGnd4 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE60 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_IgnClPsShCirGnd5 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE61 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_IgnClPsShCirGnd6 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE62 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_IgnClPsShCirGnd7 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE63 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_KnDetSens1PortAMax "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE64 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_KnDetSens1PortAMin "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE65 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_KnDetSens1PortBMax "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE66 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_KnDetSens1PortBMin "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE67 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_KnDetSens2PortAMax "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE68 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_KnDetSens2PortAMin "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE69 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_KnDetSens2PortBMax "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE6A /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_KnDetSens2PortBMin "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE6B /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_KnDetSens3PortAMax "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE6C /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_KnDetSens3PortAMin "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE6D /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_KnDetSens3PortBMax "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE6E /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_KnDetSens3PortBMin "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE6F /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_KnDetSens4PortAMax "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE70 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_KnDetSens4PortAMin "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE71 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_KnDetSens4PortBMax "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE72 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_KnDetSens4PortBMin "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE73 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_MfPsNonPlausible "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE74 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_MfPsNonPlausible2 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE75 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_MfPsOpenLoad "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE76 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_MfPsOpenLoad2 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE77 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_MfPsShCirBattLowSide "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE78 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_MfPsShCirBattLowSide2 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE79 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_MfPsShCirGndLowSide "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE7A /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_MfPsShCirGndLowSide2 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE7B /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_DevLibBattUHi "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE7C /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_DevLibBattULo "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE7D /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_DSMDummy "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE7E /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_EEPEraseErr "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE7F /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_EEPRdErr "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE80 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_EEPWrErr "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE81 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_EV1max "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE82 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_EV1min "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE83 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_EV1sig "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE84 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_EV2max "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE85 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_EV2min "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE86 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_EV2sig "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE87 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_EV3max "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE88 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_EV3min "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE89 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_EV3sig "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE8A /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_EV4max "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE8B /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_EV4min "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE8C /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_EV4sig "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE8D /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_EV5max "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE8E /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_EV5min "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE8F /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_EV5sig "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE90 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_EV6max "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE91 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_EV6min "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE92 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_EV6sig "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE93 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_EV7max "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE94 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_EV7min "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE95 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_EV7sig "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE96 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_EV8max "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE97 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_EV8min "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE98 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_EV8sig "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE99 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_EpmCaSI1ErrSig "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE9A /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_EpmCaSI1NoSigMax "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE9B /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_EpmCaSI1NoSigMin "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE9C /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_EpmCaSI1OfsErr "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE9D /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_EpmCaSI2ErrSig "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE9E /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_EpmCaSI2NoSigMax "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AE9F /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_EpmCaSI2NoSigMin "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AEA0 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_EpmCaSI2OfsErr "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AEA1 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_EpmCaSO1ErrSig "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AEA2 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_EpmCaSO1NoSigMax "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AEA3 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_EpmCaSO1NoSigMin "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AEA4 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_EpmCaSO1OfsErr "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AEA5 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_EpmCaSO2ErrSig "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AEA6 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_EpmCaSO2NoSigMax "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AEA7 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_EpmCaSO2NoSigMin "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AEA8 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_EpmCaSO2OfsErr "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AEA9 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_EpmCrSDGI "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AEAA /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_EpmCrSErrSig "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AEAB /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_EpmCrSNoSig "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AEAC /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_HDEVH_MAX_0 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AEAD /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_HDEVH_MAX_1 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AEAE /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_HDEVH_MAX_2 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AEAF /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_HDEVH_MAX_3 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AEB0 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_HDEVH_MAX_4 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AEB1 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_HDEVH_MAX_5 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AEB2 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_HDEVH_MAX_6 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AEB3 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_HDEVH_MAX_7 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AEB4 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_HDEVH_MIN_0 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AEB5 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_HDEVH_MIN_1 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AEB6 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_HDEVH_MIN_2 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AEB7 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_HDEVH_MIN_3 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AEB8 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_HDEVH_MIN_4 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AEB9 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_HDEVH_MIN_5 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AEBA /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_HDEVH_MIN_6 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AEBB /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_HDEVH_MIN_7 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AEBC /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_HDEVH_NPL_0 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AEBD /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_HDEVH_NPL_1 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AEBE /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_HDEVH_NPL_2 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AEBF /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_HDEVH_NPL_3 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AEC0 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_HDEVH_NPL_4 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AEC1 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_HDEVH_NPL_5 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AEC2 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_HDEVH_NPL_6 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AEC3 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_HDEVH_NPL_7 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AEC4 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_HDEVL_MAX_0 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AEC5 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_HDEVL_MAX_1 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AEC6 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_HDEVL_MAX_2 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AEC7 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_HDEVL_MAX_3 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AEC8 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_HDEVL_MAX_4 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AEC9 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_HDEVL_MAX_5 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AECA /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_HDEVL_MAX_6 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AECB /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_HDEVL_MAX_7 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AECC /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_HDEVL_MIN_0 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AECD /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_HDEVL_MIN_1 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AECE /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_HDEVL_MIN_2 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AECF /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_HDEVL_MIN_3 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AED0 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_HDEVL_MIN_4 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AED1 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_HDEVL_MIN_5 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AED2 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_HDEVL_MIN_6 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AED3 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_HDEVL_MIN_7 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AED4 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_HDEVL_NPL_0 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AED5 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_HDEVL_NPL_1 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AED6 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_HDEVL_NPL_2 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AED7 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_HDEVL_NPL_3 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AED8 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_HDEVL_NPL_4 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AED9 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_HDEVL_NPL_5 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AEDA /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_HDEVL_NPL_6 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AEDB /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_HDEVL_NPL_7 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AEDC /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_HDEVL_SIG_0 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AEDD /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_HDEVL_SIG_1 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AEDE /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_HDEVL_SIG_2 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AEDF /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_HDEVL_SIG_3 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AEE0 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_HDEVL_SIG_4 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AEE1 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_HDEVL_SIG_5 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AEE2 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_HDEVL_SIG_6 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AEE3 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_HDEVL_SIG_7 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AEE4 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_HSFE2max "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AEE5 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_HSFE2min "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AEE6 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_HSFE2sig "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AEE7 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_HSFEmax "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AEE8 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_HSFEmin "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AEE9 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_HSFEsig "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AEEA /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_HSHE2max "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AEEB /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_HSHE2min "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AEEC /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_HSHE2sig "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AEED /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_HSHEmax "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AEEE /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_HSHEmin "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AEEF /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_HSHEsig "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AEF0 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_HSVE2max "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AEF1 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_HSVE2maxLSF "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AEF2 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_HSVE2min "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AEF3 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_HSVE2minLSF "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AEF4 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_HSVE2sig "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AEF5 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_HSVE2sigLSF "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AEF6 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_HSVEmax "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AEF7 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_HSVEmaxLSF "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AEF8 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_HSVEmin "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AEF9 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_HSVEminLSF "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AEFA /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_HSVEsig "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AEFB /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_HSVEsigLSF "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AEFC /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_ICLSU2max "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AEFD /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_ICLSU2min "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AEFE /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_ICLSU2npl "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AEFF /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_ICLSU2sig "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AF00 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_ICLSUmax "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AF01 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_ICLSUmin "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AF02 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_ICLSUnpl "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AF03 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_ICLSUsig "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AF04 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_LSF2max "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AF05 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_LSF2min "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AF06 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_LSF2npl "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AF07 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_LSF2sig "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AF08 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_LSFmax "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AF09 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_LSFmin "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AF0A /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_LSFnpl "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AF0B /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_LSFsig "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AF0C /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_LSH2max "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AF0D /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_LSH2min "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AF0E /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_LSH2npl "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AF0F /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_LSH2sig "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AF10 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_LSHmax "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AF11 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_LSHmin "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AF12 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_LSHnpl "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AF13 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_LSHsig "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AF14 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_LSUIA2sig "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AF15 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_LSUIAsig "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AF16 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_LSUIP2max "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AF17 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_LSUIP2npl "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AF18 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_LSUIP2sig "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AF19 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_LSUIPmax "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AF1A /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_LSUIPnpl "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AF1B /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_LSUIPsig "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AF1C /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_LSUKS2max "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AF1D /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_LSUKS2min "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AF1E /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_LSUKSmax "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AF1F /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_LSUKSmin "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AF20 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_LSUUN2sig "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AF21 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_LSUUNsig "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AF22 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_LSUVM2sig "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AF23 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_LSUVMsig "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AF24 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_LSV2max "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AF25 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_LSV2min "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AF26 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_LSV2npl "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AF27 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_LSV2sig "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AF28 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_LSVmax "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AF29 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_LSVmin "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AF2A /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_LSVnpl "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AF2B /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_LSVsig "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AF2C /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_MD00max "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AF2D /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_MD00min "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AF2E /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_MD00npl "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AF2F /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_MD01max "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AF30 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_MD01min "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AF31 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_MD01npl "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AF32 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_MD02max "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AF33 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_MD02min "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AF34 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_MD02npl "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AF35 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_MD03max "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AF36 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_MD03min "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AF37 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_MD03npl "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AF38 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_MD04max "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AF39 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_MD04min "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AF3A /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_MD04npl "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AF3B /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_MD05max "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AF3C /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_MD05min "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AF3D /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_MD05npl "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AF3E /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_MD06max "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AF3F /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_MD06min "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AF40 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_MD06npl "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AF41 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_MD07max "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AF42 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_MD07min "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AF43 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_MD07npl "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AF44 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_MDmax "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AF45 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_MDmin "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AF46 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_MDnpl "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AF47 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_MRlyErlyOpng "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AF48 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_MRlyStk "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AF49 /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_PLLSUmax "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AF4A /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_PLLSUmin "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AF4B /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_PLLSUnpl "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AF4C /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_PLLSUsig "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AF4D /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_SWReset_0 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AF4E /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_SWReset_1 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AF4F /end MEASUREMENT
/begin MEASUREMENT DFC_b.LDF_SWReset_2 "" UBYTE DFC_OneToOne 1 100 0.00 1.000 BIT_MASK 0x10 FORMAT "%5.3" ECU_ADDRESS 0xD001AF50 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_Unused "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001ADA8 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_BusDiagBusOffErrPasNodeA "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001ADA9 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_BusDiagBusOffErrPasNodeB "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001ADAA /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_BusDiagBusOffErrPasNodeC "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001ADAB /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_BusDiagBusOffErrPasNodeD "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001ADAC /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_BusDiagBusOffNodeA "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001ADAD /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_BusDiagBusOffNodeB "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001ADAE /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_BusDiagBusOffNodeC "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001ADAF /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_BusDiagBusOffNodeD "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001ADB0 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_ComCANG1_HDL0TO "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001ADB1 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_ComCANG1_HDL10TO "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001ADB2 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_ComCANG1_HDL11TO "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001ADB3 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_ComCANG1_HDL12TO "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001ADB4 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_ComCANG1_HDL13TO "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001ADB5 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_ComCANG1_HDL14TO "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001ADB6 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_ComCANG1_HDL15TO "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001ADB7 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_ComCANG1_HDL16TO "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001ADB8 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_ComCANG1_HDL17TO "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001ADB9 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_ComCANG1_HDL18TO "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001ADBA /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_ComCANG1_HDL19TO "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001ADBB /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_ComCANG1_HDL1TO "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001ADBC /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_ComCANG1_HDL20TO "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001ADBD /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_ComCANG1_HDL21TO "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001ADBE /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_ComCANG1_HDL22TO "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001ADBF /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_ComCANG1_HDL23TO "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001ADC0 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_ComCANG1_HDL24TO "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001ADC1 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_ComCANG1_HDL2TO "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001ADC2 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_ComCANG1_HDL3TO "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001ADC3 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_ComCANG1_HDL4TO "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001ADC4 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_ComCANG1_HDL5TO "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001ADC5 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_ComCANG1_HDL6TO "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001ADC6 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_ComCANG1_HDL7TO "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001ADC7 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_ComCANG1_HDL8TO "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001ADC8 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_ComCANG1_HDL9TO "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001ADC9 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_ComCANG2_HDL0TO "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001ADCA /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_ComCANG2_HDL10TO "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001ADCB /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_ComCANG2_HDL11TO "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001ADCC /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_ComCANG2_HDL12TO "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001ADCD /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_ComCANG2_HDL13TO "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001ADCE /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_ComCANG2_HDL14TO "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001ADCF /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_ComCANG2_HDL15TO "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001ADD0 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_ComCANG2_HDL16TO "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001ADD1 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_ComCANG2_HDL17TO "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001ADD2 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_ComCANG2_HDL18TO "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001ADD3 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_ComCANG2_HDL19TO "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001ADD4 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_ComCANG2_HDL1TO "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001ADD5 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_ComCANG2_HDL20TO "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001ADD6 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_ComCANG2_HDL21TO "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001ADD7 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_ComCANG2_HDL22TO "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001ADD8 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_ComCANG2_HDL23TO "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001ADD9 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_ComCANG2_HDL24TO "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001ADDA /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_ComCANG2_HDL2TO "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001ADDB /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_ComCANG2_HDL3TO "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001ADDC /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_ComCANG2_HDL4TO "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001ADDD /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_ComCANG2_HDL5TO "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001ADDE /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_ComCANG2_HDL6TO "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001ADDF /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_ComCANG2_HDL7TO "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001ADE0 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_ComCANG2_HDL8TO "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001ADE1 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_ComCANG2_HDL9TO "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001ADE2 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_ComCANG3_HDL0TO "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001ADE3 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_ComCANG3_HDL10TO "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001ADE4 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_ComCANG3_HDL11TO "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001ADE5 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_ComCANG3_HDL12TO "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001ADE6 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_ComCANG3_HDL13TO "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001ADE7 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_ComCANG3_HDL14TO "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001ADE8 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_ComCANG3_HDL15TO "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001ADE9 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_ComCANG3_HDL16TO "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001ADEA /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_ComCANG3_HDL17TO "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001ADEB /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_ComCANG3_HDL18TO "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001ADEC /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_ComCANG3_HDL19TO "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001ADED /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_ComCANG3_HDL1TO "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001ADEE /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_ComCANG3_HDL20TO "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001ADEF /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_ComCANG3_HDL21TO "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001ADF0 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_ComCANG3_HDL22TO "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001ADF1 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_ComCANG3_HDL23TO "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001ADF2 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_ComCANG3_HDL24TO "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001ADF3 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_ComCANG3_HDL2TO "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001ADF4 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_ComCANG3_HDL3TO "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001ADF5 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_ComCANG3_HDL4TO "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001ADF6 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_ComCANG3_HDL5TO "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001ADF7 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_ComCANG3_HDL6TO "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001ADF8 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_ComCANG3_HDL7TO "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001ADF9 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_ComCANG3_HDL8TO "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001ADFA /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_ComCANG3_HDL9TO "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001ADFB /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_ComCANG4_HDL0TO "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001ADFC /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_ComCANG4_HDL10TO "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001ADFD /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_ComCANG4_HDL11TO "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001ADFE /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_ComCANG4_HDL12TO "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001ADFF /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_ComCANG4_HDL13TO "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE00 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_ComCANG4_HDL14TO "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE01 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_ComCANG4_HDL15TO "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE02 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_ComCANG4_HDL16TO "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE03 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_ComCANG4_HDL17TO "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE04 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_ComCANG4_HDL18TO "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE05 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_ComCANG4_HDL19TO "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE06 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_ComCANG4_HDL1TO "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE07 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_ComCANG4_HDL20TO "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE08 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_ComCANG4_HDL21TO "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE09 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_ComCANG4_HDL22TO "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE0A /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_ComCANG4_HDL23TO "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE0B /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_ComCANG4_HDL24TO "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE0C /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_ComCANG4_HDL2TO "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE0D /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_ComCANG4_HDL3TO "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE0E /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_ComCANG4_HDL4TO "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE0F /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_ComCANG4_HDL5TO "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE10 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_ComCANG4_HDL6TO "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE11 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_ComCANG4_HDL7TO "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE12 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_ComCANG4_HDL8TO "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE13 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_ComCANG4_HDL9TO "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE14 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_Cy150SpiCom "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE15 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_Cy320SpiCom "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE16 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_MonUMaxSupply1 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE17 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_MonUMaxSupply2 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE18 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_MonUMaxSupply3 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE19 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_MonUMinSupply1 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE1A /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_MonUMinSupply2 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE1B /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_MonUMinSupply3 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE1C /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_SSpMon1 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE1D /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_SSpMon1OV "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE1E /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_SSpMon1UV "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE1F /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_SSpMon2 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE20 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_SSpMon2OV "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE21 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_SSpMon2UV "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE22 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_SSpMon3 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE23 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_SSpMon3OV "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE24 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_SSpMon3UV "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE25 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_HDEVK_MIN_0 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE26 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_HDEVK_MIN_1 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE27 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_HDEVK_NPL_0 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE28 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_HDEVK_NPL_1 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE29 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_HDEVK_SIG_0 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE2A /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_HDEVK_SIG_1 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE2B /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_IgnClPsClOpen0 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE2C /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_IgnClPsClOpen1 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE2D /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_IgnClPsClOpen2 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE2E /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_IgnClPsClOpen3 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE2F /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_IgnClPsClOpen4 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE30 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_IgnClPsClOpen5 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE31 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_IgnClPsClOpen6 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE32 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_IgnClPsClOpen7 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE33 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_IgnClPsClShCir0 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE34 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_IgnClPsClShCir1 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE35 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_IgnClPsClShCir2 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE36 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_IgnClPsClShCir3 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE37 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_IgnClPsClShCir4 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE38 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_IgnClPsClShCir5 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE39 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_IgnClPsClShCir6 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE3A /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_IgnClPsClShCir7 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE3B /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_IgnClPsClUnExpt0 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE3C /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_IgnClPsClUnExpt1 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE3D /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_IgnClPsClUnExpt2 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE3E /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_IgnClPsClUnExpt3 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE3F /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_IgnClPsClUnExpt4 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE40 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_IgnClPsClUnExpt5 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE41 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_IgnClPsClUnExpt6 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE42 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_IgnClPsClUnExpt7 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE43 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_IgnClPsDevIdentErr1 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE44 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_IgnClPsDevIdentErr2 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE45 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_IgnClPsDevInitErr1 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE46 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_IgnClPsDevInitErr2 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE47 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_IgnClPsDevOscErr1 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE48 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_IgnClPsDevOscErr2 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE49 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_IgnClPsDevSpiErr1 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE4A /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_IgnClPsDevSpiErr2 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE4B /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_IgnClPsOpenLoad0 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE4C /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_IgnClPsOpenLoad1 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE4D /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_IgnClPsOpenLoad2 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE4E /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_IgnClPsOpenLoad3 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE4F /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_IgnClPsOpenLoad4 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE50 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_IgnClPsOpenLoad5 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE51 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_IgnClPsOpenLoad6 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE52 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_IgnClPsOpenLoad7 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE53 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_IgnClPsShCirBatt0 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE54 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_IgnClPsShCirBatt1 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE55 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_IgnClPsShCirBatt2 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE56 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_IgnClPsShCirBatt3 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE57 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_IgnClPsShCirBatt4 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE58 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_IgnClPsShCirBatt5 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE59 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_IgnClPsShCirBatt6 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE5A /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_IgnClPsShCirBatt7 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE5B /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_IgnClPsShCirGnd0 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE5C /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_IgnClPsShCirGnd1 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE5D /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_IgnClPsShCirGnd2 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE5E /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_IgnClPsShCirGnd3 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE5F /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_IgnClPsShCirGnd4 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE60 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_IgnClPsShCirGnd5 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE61 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_IgnClPsShCirGnd6 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE62 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_IgnClPsShCirGnd7 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE63 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_KnDetSens1PortAMax "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE64 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_KnDetSens1PortAMin "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE65 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_KnDetSens1PortBMax "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE66 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_KnDetSens1PortBMin "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE67 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_KnDetSens2PortAMax "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE68 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_KnDetSens2PortAMin "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE69 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_KnDetSens2PortBMax "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE6A /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_KnDetSens2PortBMin "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE6B /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_KnDetSens3PortAMax "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE6C /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_KnDetSens3PortAMin "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE6D /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_KnDetSens3PortBMax "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE6E /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_KnDetSens3PortBMin "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE6F /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_KnDetSens4PortAMax "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE70 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_KnDetSens4PortAMin "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE71 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_KnDetSens4PortBMax "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE72 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_KnDetSens4PortBMin "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE73 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_MfPsNonPlausible "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE74 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_MfPsNonPlausible2 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE75 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_MfPsOpenLoad "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE76 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_MfPsOpenLoad2 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE77 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_MfPsShCirBattLowSide "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE78 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_MfPsShCirBattLowSide2 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE79 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_MfPsShCirGndLowSide "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE7A /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_MfPsShCirGndLowSide2 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE7B /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_DevLibBattUHi "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE7C /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_DevLibBattULo "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE7D /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_DSMDummy "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE7E /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_EEPEraseErr "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE7F /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_EEPRdErr "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE80 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_EEPWrErr "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE81 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_EV1max "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE82 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_EV1min "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE83 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_EV1sig "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE84 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_EV2max "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE85 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_EV2min "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE86 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_EV2sig "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE87 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_EV3max "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE88 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_EV3min "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE89 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_EV3sig "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE8A /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_EV4max "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE8B /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_EV4min "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE8C /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_EV4sig "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE8D /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_EV5max "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE8E /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_EV5min "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE8F /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_EV5sig "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE90 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_EV6max "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE91 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_EV6min "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE92 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_EV6sig "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE93 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_EV7max "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE94 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_EV7min "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE95 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_EV7sig "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE96 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_EV8max "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE97 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_EV8min "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE98 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_EV8sig "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE99 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_EpmCaSI1ErrSig "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE9A /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_EpmCaSI1NoSigMax "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE9B /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_EpmCaSI1NoSigMin "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE9C /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_EpmCaSI1OfsErr "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE9D /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_EpmCaSI2ErrSig "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE9E /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_EpmCaSI2NoSigMax "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AE9F /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_EpmCaSI2NoSigMin "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AEA0 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_EpmCaSI2OfsErr "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AEA1 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_EpmCaSO1ErrSig "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AEA2 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_EpmCaSO1NoSigMax "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AEA3 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_EpmCaSO1NoSigMin "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AEA4 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_EpmCaSO1OfsErr "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AEA5 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_EpmCaSO2ErrSig "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AEA6 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_EpmCaSO2NoSigMax "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AEA7 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_EpmCaSO2NoSigMin "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AEA8 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_EpmCaSO2OfsErr "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AEA9 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_EpmCrSDGI "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AEAA /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_EpmCrSErrSig "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AEAB /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_EpmCrSNoSig "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AEAC /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_HDEVH_MAX_0 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AEAD /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_HDEVH_MAX_1 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AEAE /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_HDEVH_MAX_2 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AEAF /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_HDEVH_MAX_3 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AEB0 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_HDEVH_MAX_4 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AEB1 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_HDEVH_MAX_5 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AEB2 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_HDEVH_MAX_6 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AEB3 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_HDEVH_MAX_7 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AEB4 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_HDEVH_MIN_0 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AEB5 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_HDEVH_MIN_1 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AEB6 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_HDEVH_MIN_2 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AEB7 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_HDEVH_MIN_3 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AEB8 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_HDEVH_MIN_4 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AEB9 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_HDEVH_MIN_5 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AEBA /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_HDEVH_MIN_6 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AEBB /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_HDEVH_MIN_7 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AEBC /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_HDEVH_NPL_0 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AEBD /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_HDEVH_NPL_1 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AEBE /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_HDEVH_NPL_2 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AEBF /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_HDEVH_NPL_3 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AEC0 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_HDEVH_NPL_4 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AEC1 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_HDEVH_NPL_5 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AEC2 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_HDEVH_NPL_6 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AEC3 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_HDEVH_NPL_7 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AEC4 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_HDEVL_MAX_0 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AEC5 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_HDEVL_MAX_1 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AEC6 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_HDEVL_MAX_2 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AEC7 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_HDEVL_MAX_3 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AEC8 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_HDEVL_MAX_4 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AEC9 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_HDEVL_MAX_5 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AECA /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_HDEVL_MAX_6 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AECB /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_HDEVL_MAX_7 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AECC /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_HDEVL_MIN_0 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AECD /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_HDEVL_MIN_1 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AECE /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_HDEVL_MIN_2 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AECF /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_HDEVL_MIN_3 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AED0 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_HDEVL_MIN_4 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AED1 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_HDEVL_MIN_5 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AED2 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_HDEVL_MIN_6 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AED3 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_HDEVL_MIN_7 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AED4 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_HDEVL_NPL_0 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AED5 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_HDEVL_NPL_1 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AED6 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_HDEVL_NPL_2 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AED7 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_HDEVL_NPL_3 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AED8 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_HDEVL_NPL_4 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AED9 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_HDEVL_NPL_5 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AEDA /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_HDEVL_NPL_6 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AEDB /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_HDEVL_NPL_7 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AEDC /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_HDEVL_SIG_0 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AEDD /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_HDEVL_SIG_1 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AEDE /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_HDEVL_SIG_2 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AEDF /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_HDEVL_SIG_3 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AEE0 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_HDEVL_SIG_4 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AEE1 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_HDEVL_SIG_5 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AEE2 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_HDEVL_SIG_6 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AEE3 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_HDEVL_SIG_7 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AEE4 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_HSFE2max "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AEE5 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_HSFE2min "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AEE6 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_HSFE2sig "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AEE7 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_HSFEmax "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AEE8 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_HSFEmin "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AEE9 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_HSFEsig "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AEEA /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_HSHE2max "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AEEB /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_HSHE2min "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AEEC /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_HSHE2sig "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AEED /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_HSHEmax "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AEEE /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_HSHEmin "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AEEF /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_HSHEsig "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AEF0 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_HSVE2max "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AEF1 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_HSVE2maxLSF "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AEF2 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_HSVE2min "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AEF3 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_HSVE2minLSF "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AEF4 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_HSVE2sig "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AEF5 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_HSVE2sigLSF "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AEF6 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_HSVEmax "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AEF7 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_HSVEmaxLSF "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AEF8 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_HSVEmin "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AEF9 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_HSVEminLSF "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AEFA /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_HSVEsig "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AEFB /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_HSVEsigLSF "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AEFC /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_ICLSU2max "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AEFD /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_ICLSU2min "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AEFE /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_ICLSU2npl "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AEFF /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_ICLSU2sig "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AF00 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_ICLSUmax "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AF01 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_ICLSUmin "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AF02 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_ICLSUnpl "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AF03 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_ICLSUsig "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AF04 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_LSF2max "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AF05 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_LSF2min "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AF06 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_LSF2npl "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AF07 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_LSF2sig "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AF08 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_LSFmax "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AF09 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_LSFmin "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AF0A /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_LSFnpl "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AF0B /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_LSFsig "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AF0C /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_LSH2max "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AF0D /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_LSH2min "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AF0E /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_LSH2npl "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AF0F /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_LSH2sig "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AF10 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_LSHmax "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AF11 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_LSHmin "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AF12 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_LSHnpl "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AF13 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_LSHsig "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AF14 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_LSUIA2sig "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AF15 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_LSUIAsig "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AF16 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_LSUIP2max "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AF17 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_LSUIP2npl "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AF18 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_LSUIP2sig "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AF19 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_LSUIPmax "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AF1A /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_LSUIPnpl "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AF1B /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_LSUIPsig "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AF1C /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_LSUKS2max "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AF1D /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_LSUKS2min "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AF1E /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_LSUKSmax "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AF1F /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_LSUKSmin "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AF20 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_LSUUN2sig "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AF21 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_LSUUNsig "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AF22 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_LSUVM2sig "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AF23 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_LSUVMsig "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AF24 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_LSV2max "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AF25 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_LSV2min "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AF26 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_LSV2npl "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AF27 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_LSV2sig "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AF28 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_LSVmax "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AF29 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_LSVmin "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AF2A /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_LSVnpl "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AF2B /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_LSVsig "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AF2C /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_MD00max "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AF2D /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_MD00min "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AF2E /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_MD00npl "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AF2F /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_MD01max "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AF30 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_MD01min "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AF31 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_MD01npl "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AF32 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_MD02max "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AF33 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_MD02min "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AF34 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_MD02npl "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AF35 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_MD03max "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AF36 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_MD03min "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AF37 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_MD03npl "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AF38 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_MD04max "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AF39 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_MD04min "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AF3A /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_MD04npl "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AF3B /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_MD05max "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AF3C /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_MD05min "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AF3D /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_MD05npl "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AF3E /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_MD06max "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AF3F /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_MD06min "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AF40 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_MD06npl "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AF41 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_MD07max "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AF42 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_MD07min "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AF43 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_MD07npl "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AF44 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_MDmax "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AF45 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_MDmin "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AF46 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_MDnpl "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AF47 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_MRlyErlyOpng "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AF48 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_MRlyStk "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AF49 /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_PLLSUmax "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AF4A /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_PLLSUmin "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AF4B /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_PLLSUnpl "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AF4C /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_PLLSUsig "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AF4D /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_SWReset_0 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AF4E /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_SWReset_1 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AF4F /end MEASUREMENT
/begin MEASUREMENT DFC_st.DFC_SWReset_2 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AF50 /end MEASUREMENT
/begin MEASUREMENT DFC_stClctFault_mp "" UWORD DFC_OneToOne 1 100 0.00 65535.00 FORMAT "%8.2" ARRAY_SIZE 27 ECU_ADDRESS 0xD0017A90 /end MEASUREMENT
/begin MEASUREMENT DFC_stClctTst_mp "" UWORD DFC_OneToOne 1 100 0.00 65535.00 FORMAT "%8.2" ARRAY_SIZE 27 ECU_ADDRESS 0xD0017AC6 /end MEASUREMENT
/begin MEASUREMENT DFC_stFinal "" UWORD DFC_OneToOne 1 100 0.00 65535.00 FORMAT "%8.2" ARRAY_SIZE 27 ECU_ADDRESS 0xD001669E /end MEASUREMENT
/begin MEASUREMENT DFC_stMaxFlt "" UWORD DFC_OneToOne 1 100 0.00 65535.00 FORMAT "%8.2" ARRAY_SIZE 27 ECU_ADDRESS 0xD00166D4 /end MEASUREMENT
/begin MEASUREMENT DFC_stRun "" UWORD DFC_OneToOne 1 100 0.00 65535.00 FORMAT "%8.2" ARRAY_SIZE 27 ECU_ADDRESS 0xD0016668 /end MEASUREMENT
/begin MEASUREMENT DFES_ChkLstDltDemExCond_mp "" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0017D6B /end MEASUREMENT
/begin MEASUREMENT DFES_ctDef "" UBYTE DFES_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ARRAY_SIZE 10 ECU_ADDRESS 0xD001AFB6 /end MEASUREMENT
/begin MEASUREMENT DFES_ctDel "" UBYTE DFES_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ARRAY_SIZE 10 ECU_ADDRESS 0xD001AFDE /end MEASUREMENT
/begin MEASUREMENT DFES_ctEntry "" UBYTE DFES_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001733D /end MEASUREMENT
/begin MEASUREMENT DFES_ctFrq "" UBYTE DFES_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ARRAY_SIZE 10 ECU_ADDRESS 0xD001AFE8 /end MEASUREMENT
/begin MEASUREMENT DFES_ctManuDef "" UBYTE DFES_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ARRAY_SIZE 10 ECU_ADDRESS 0xD001AFCA /end MEASUREMENT
/begin MEASUREMENT DFES_ctManuOk "" UBYTE DFES_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ARRAY_SIZE 10 ECU_ADDRESS 0xD001AFD4 /end MEASUREMENT
/begin MEASUREMENT DFES_ctMIL "" UBYTE DFES_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001733B /end MEASUREMENT
/begin MEASUREMENT DFES_ctOBD "" UBYTE DFES_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0017339 /end MEASUREMENT
/begin MEASUREMENT DFES_ctOBDPend "" UBYTE DFES_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001733A /end MEASUREMENT
/begin MEASUREMENT DFES_ctOk "" UBYTE DFES_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ARRAY_SIZE 10 ECU_ADDRESS 0xD001AFC0 /end MEASUREMENT
/begin MEASUREMENT DFES_ctSrv "" UBYTE DFES_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001733C /end MEASUREMENT
/begin MEASUREMENT DFES_EnvBlock "" UBYTE DFES_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ARRAY_SIZE 40 ECU_ADDRESS 0xD001B006 /end MEASUREMENT
/begin MEASUREMENT DFES_FrzFrVal "" UBYTE DFES_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ARRAY_SIZE 20 ECU_ADDRESS 0xD001AFF2 /end MEASUREMENT
/begin MEASUREMENT DFES_idxHash "" UBYTE DFES_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ARRAY_SIZE 10 ECU_ADDRESS 0xD0017323 /end MEASUREMENT
/begin MEASUREMENT DFES_idxLink "" UBYTE DFES_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ARRAY_SIZE 10 ECU_ADDRESS 0xD001730F /end MEASUREMENT
/begin MEASUREMENT DFES_idxPrioQueue "" UBYTE DFES_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ARRAY_SIZE 10 ECU_ADDRESS 0xD0017319 /end MEASUREMENT
/begin MEASUREMENT DFES_idxSequence "" UBYTE DFES_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ARRAY_SIZE 10 ECU_ADDRESS 0xD001B02E /end MEASUREMENT
/begin MEASUREMENT DFES_idxVisible "" UBYTE DFES_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ARRAY_SIZE 10 ECU_ADDRESS 0xD00172F1 /end MEASUREMENT
/begin COMPU_METHOD DFC_OneToOne "" RAT_FUNC "%6.2" "-" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD DFES_OneToOne "" RAT_FUNC "%6.2" "-" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD OneToOne "" RAT_FUNC "%6.2" "No Unit" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD r_q9p765625Em4_Ohm "" RAT_FUNC "%6.5" "Ohm" COEFFS 0 65536 0 0 0 64 /end COMPU_METHOD
/begin COMPU_METHOD SCR_DISABLE_SY_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF SCR_DISABLE_SY_Compu /end COMPU_METHOD
/begin COMPU_VTAB SCR_DISABLE_SY_Compu "" TAB_VERB 2 0 "False" 1 "True" /end COMPU_VTAB
/begin COMPU_METHOD SCR_DmStp0001 "" RAT_FUNC "%6.5" "mg/Step" COEFFS 0 1000 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD SCR_kPa_10 "" RAT_FUNC "%6.1" "kPa" COEFFS 0 0.1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD SCR_kPa_100 "" RAT_FUNC "%6.0" "kPa" COEFFS 0 0.01 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD SCR_Mass01 "" RAT_FUNC "%6.3" "mg" COEFFS 0 10 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD SCR_Volt_q0p0001227 "" RAT_FUNC "%6.5" "V" COEFFS 0 8192 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD SHFTR_SY_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF SHFTR_SY_Compu /end COMPU_METHOD
/begin COMPU_VTAB SHFTR_SY_Compu "" TAB_VERB 2 0 "no shift register" 1 "one shift register" /end COMPU_VTAB
/begin COMPU_METHOD Signals_OneToOne "" RAT_FUNC "%6.2" "" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD Sig_I15031_LeanAppl_SY_Compu "" RAT_FUNC "%6.2" "" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD Soot_gPerLtr "" RAT_FUNC "%6.4" "g/l" COEFFS 0 100 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD SotMassPerDist "" RAT_FUNC "%7.6" "g/km" COEFFS 0 10000 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD SotMassPerSec "" RAT_FUNC "%6.3" "g/s" COEFFS 0 10 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD SotMassPerTime "" RAT_FUNC "%6.4" "mg/s" COEFFS 0 100 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD SotMsPerkm_COMPU "" RAT_FUNC "%6.5" "g/km" COEFFS 0 8192 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD SotMs_KgPrSec_COMPU "" RAT_FUNC "%6.2" "kg/s" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD SOxMassPerTime "" RAT_FUNC "%7.6" "mg/s" COEFFS 0 10000 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD SpaVel "" RAT_FUNC "%6.1" "l/h" COEFFS 0 0.1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD SpecHeatFine "" RAT_FUNC "%6.3" "J/Kg/K" COEFFS 0 5 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD SpecificHeat "" RAT_FUNC "%7.6" "J/g/K" COEFFS 0 10000 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD spg_q0p00078 "" RAT_FUNC "%6.5" "V" COEFFS 0 1280 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD spg_ub_q0p0052_o0p2 "" RAT_FUNC "%6.3" "V" COEFFS 0 255 51 0 0 1.33 /end COMPU_METHOD
/begin COMPU_METHOD SqrVltg_s "" RAT_FUNC "%6.3" "V^2s" COEFFS 0 10 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD STM_SY_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF STM_SY_Compu /end COMPU_METHOD
/begin COMPU_VTAB STM_SY_Compu "" TAB_VERB 2 0 "STM not used" 1 "STM used" /end COMPU_VTAB
/begin COMPU_METHOD stroke_pml "" RAT_FUNC "%6.3" "1/ml" COEFFS 0 10 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD STSP_SY_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF STSP_SY_Compu /end COMPU_METHOD
/begin COMPU_VTAB STSP_SY_Compu "" TAB_VERB 2 0 "FALSE" 1 "TRUE" /end COMPU_VTAB
/begin COMPU_METHOD SVCrnt_mA_COMPU "" RAT_FUNC "%6.1" "mA" COEFFS 0 0.0341 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD SVS_SY_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF SVS_SY_Compu /end COMPU_METHOD
/begin COMPU_VTAB SVS_SY_Compu "" TAB_VERB 2 0 "False" 1 "True" /end COMPU_VTAB
/begin COMPU_METHOD SYC_FSTSWOFF_SY_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF SYC_FSTSWOFF_SY_Compu /end COMPU_METHOD
/begin COMPU_VTAB SYC_FSTSWOFF_SY_Compu "" TAB_VERB 2 0 "False" 1 "True" /end COMPU_VTAB
/begin COMPU_METHOD SYC_T15POSTPREDRV_SWRST_SY_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF SYC_T15POSTPREDRV_SWRST_SY_Compu /end COMPU_METHOD
/begin COMPU_VTAB SYC_T15POSTPREDRV_SWRST_SY_Compu "" TAB_VERB 2 0 "False" 1 "True" /end COMPU_VTAB
/begin COMPU_METHOD SYC_T15RSTSIM_SY_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF SYC_T15RSTSIM_SY_Compu /end COMPU_METHOD
/begin COMPU_VTAB SYC_T15RSTSIM_SY_Compu "" TAB_VERB 2 0 "False" 1 "True" /end COMPU_VTAB
/begin COMPU_METHOD SYC_UNLIMNWM_SY_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF SYC_UNLIMNWM_SY_Compu /end COMPU_METHOD
/begin COMPU_VTAB SYC_UNLIMNWM_SY_Compu "" TAB_VERB 2 0 "False" 1 "True" /end COMPU_VTAB
/begin COMPU_METHOD SYC_WREEPBLK_SY_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF SYC_WREEPBLK_SY_Compu /end COMPU_METHOD
/begin COMPU_VTAB SYC_WREEPBLK_SY_Compu "" TAB_VERB 2 0 "EEP-Block for SyC is not written" 1 "EEP-Block for SyC is written" /end COMPU_VTAB
/begin COMPU_METHOD SY_2HDP2_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF SY_2HDP2_Compu /end COMPU_METHOD
/begin COMPU_VTAB SY_2HDP2_Compu "" TAB_VERB 2 0 "1 HDP" 1 "2 HDP" /end COMPU_VTAB
/begin COMPU_METHOD SY_AAV_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF SY_AAV_Compu /end COMPU_METHOD
/begin COMPU_VTAB SY_AAV_Compu "" TAB_VERB 2 0 "kein Aktivkohlefilter-Absperrventil vorhanden" 1 "Aktivkohlefilter-Absperrventil vorhanden" /end COMPU_VTAB
/begin COMPU_METHOD SY_ABGYVBP_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF SY_ABGYVBP_Compu /end COMPU_METHOD
/begin COMPU_VTAB SY_ABGYVBP_Compu "" TAB_VERB 5 0 "keine Y-Zusammenführung" 5 "Y-Zusammenführung vor Bauteileposition 5" 9 "Y-Zusammenführung vor Bauteileposition 9" 12 "Y-Zusammenführung vor Bauteileposition 12" 13 "Y-Zusammenführung vor Bauteileposition 13" /end COMPU_VTAB
/begin COMPU_METHOD SY_ABMZND_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF SY_ABMZND_Compu /end COMPU_METHOD
/begin COMPU_VTAB SY_ABMZND_Compu "" TAB_VERB 2 0 "keine Einspritzausblendung bei Zuendfehler" 1 "Einspritzausblendung bei Zuendfehler" /end COMPU_VTAB
/begin COMPU_METHOD SY_AGR_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF SY_AGR_Compu /end COMPU_METHOD
/begin COMPU_VTAB SY_AGR_Compu "" TAB_VERB 2 0 "FALSE" 1 "TRUE" /end COMPU_VTAB
/begin COMPU_METHOD SY_AHRLSU_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF SY_AHRLSU_Compu /end COMPU_METHOD
/begin COMPU_VTAB SY_AHRLSU_Compu "" TAB_VERB 3 0 "Keine Adaption" 1 "Ist Widerstand Adaption" 2 "Solltemperatur Adaption" /end COMPU_VTAB
/begin COMPU_METHOD SY_AIRBAG_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF SY_AIRBAG_Compu /end COMPU_METHOD
/begin COMPU_VTAB SY_AIRBAG_Compu "" TAB_VERB 2 0 "kein Airbagsignal verfügbar" 1 "Airbagsignal verfügbar" /end COMPU_VTAB
/begin COMPU_METHOD SY_ATLB_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF SY_ATLB_Compu /end COMPU_METHOD
/begin COMPU_VTAB SY_ATLB_Compu "" TAB_VERB 2 0 "keine Turbo-Bypassklappe" 1 "Turbo-Bypassklappe" /end COMPU_VTAB
/begin COMPU_METHOD SY_ATURB_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF SY_ATURB_Compu /end COMPU_METHOD
/begin COMPU_VTAB SY_ATURB_Compu "" TAB_VERB 4 0 "no_turbine" 1 "wastegate" 2 "vtg" 3 "varturb" /end COMPU_VTAB
/begin COMPU_METHOD SY_AUFLAD2_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF SY_AUFLAD2_Compu /end COMPU_METHOD
/begin COMPU_VTAB SY_AUFLAD2_Compu "" TAB_VERB 2 0 "no_2_bank_charging" 1 "2_bank_charging" /end COMPU_VTAB
/begin COMPU_METHOD SY_AUFLAD_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF SY_AUFLAD_Compu /end COMPU_METHOD
/begin COMPU_VTAB SY_AUFLAD_Compu "" TAB_VERB 2 0 "no_supercharging" 1 "supercharging" /end COMPU_VTAB
/begin COMPU_METHOD SY_BATTSG_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF SY_BATTSG_Compu /end COMPU_METHOD
/begin COMPU_VTAB SY_BATTSG_Compu "" TAB_VERB 2 0 "kein 2 Batterie Boardkonzept" 1 "2 Batterie Boardkonzept" /end COMPU_VTAB
/begin COMPU_METHOD SY_BDE_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF SY_BDE_Compu /end COMPU_METHOD
/begin COMPU_VTAB SY_BDE_Compu "" TAB_VERB 2 0 "Saugrohreinspritzer" 1 "Benzindirekteinspritzer" /end COMPU_VTAB
/begin COMPU_METHOD SY_BUKLSU_Compu "" RAT_FUNC "%6.2" "" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD SY_CJ125_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF SY_CJ125_Compu /end COMPU_METHOD
/begin COMPU_VTAB SY_CJ125_Compu "" TAB_VERB 3 0 "0 CJ125 Bausteine im Steuergerät verbaut" 1 "1 CJ125 Baustein im Steuergerät verbaut" 2 "2 CJ125 Bausteine im Steuergerät verbaut" /end COMPU_VTAB
/begin COMPU_METHOD SY_CJ840_Compu "" RAT_FUNC "%6.2" "" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD SY_CJ841_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF SY_CJ841_Compu /end COMPU_METHOD
/begin COMPU_VTAB SY_CJ841_Compu "" TAB_VERB 3 0 "no CJ841" 1 "one CJ841" 2 "two CJ841" /end COMPU_VTAB
/begin COMPU_METHOD SY_CJ870_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF SY_CJ870_Compu /end COMPU_METHOD
/begin COMPU_VTAB SY_CJ870_Compu "" TAB_VERB 3 0 "no CJ870" 1 "one CJ870" 2 "two CJ870" /end COMPU_VTAB
/begin COMPU_METHOD SY_CK200LS_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF SY_CK200LS_Compu /end COMPU_METHOD
/begin COMPU_VTAB SY_CK200LS_Compu "" TAB_VERB 2 0 "low side switch high impedance" 1 "low side switch function (input,!reset)" /end COMPU_VTAB
/begin COMPU_METHOD SY_CK200MO_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF SY_CK200MO_Compu /end COMPU_METHOD
/begin COMPU_VTAB SY_CK200MO_Compu "" TAB_VERB 2 0 "U-Mode" 1 "I-Mode" /end COMPU_VTAB
/begin COMPU_METHOD SY_CK200_Compu "" RAT_FUNC "%6.2" "" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD SY_CK240_Compu "" RAT_FUNC "%6.2" "" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD SY_CNG_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF SY_CNG_Compu /end COMPU_METHOD
/begin COMPU_VTAB SY_CNG_Compu "" TAB_VERB 5 0 "Kein System mit CNG" 1 "System mit CNG" 2 "System mit CNG und EOBD" 3 "System mit CNG Fehlerpfade ASV1...5" 4 "System mit CNG Plattform" /end COMPU_VTAB
/begin COMPU_METHOD SY_DAPRID_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF SY_DAPRID_Compu /end COMPU_METHOD
/begin COMPU_VTAB SY_DAPRID_Compu "" TAB_VERB 6 0 "keine Zuordnung" 1 "ME 9.7 NGV" 2 "ME 17.7 UHP" 3 "MED 17.7.1 MoVE" 4 "MED 17.7.2 M270/M274" 5 "M276Desla" /end COMPU_VTAB
/begin COMPU_METHOD SY_DFPMVAR_Compu "" RAT_FUNC "%6.2" "" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD SY_DHDEVOE_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF SY_DHDEVOE_Compu /end COMPU_METHOD
/begin COMPU_VTAB SY_DHDEVOE_Compu "" TAB_VERB 2 0 "no_error_reaction" 1 "error_reaction" /end COMPU_VTAB
/begin COMPU_METHOD SY_DIONDE_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF SY_DIONDE_Compu /end COMPU_METHOD
/begin COMPU_VTAB SY_DIONDE_Compu "" TAB_VERB 2 0 "False" 1 "True" /end COMPU_VTAB
/begin COMPU_METHOD SY_DMDTAL_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF SY_DMDTAL_Compu /end COMPU_METHOD
/begin COMPU_VTAB SY_DMDTAL_Compu "" TAB_VERB 2 0 "keine Unterdrückung MIL an bei leerem Tank" 1 "Unterdrückung MIL an bei leerem Tank" /end COMPU_VTAB
/begin COMPU_METHOD SY_DMDZAG_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF SY_DMDZAG_Compu /end COMPU_METHOD
/begin COMPU_VTAB SY_DMDZAG_Compu "" TAB_VERB 3 0 "Misfire generation with DMDZAG not available" 1 "Misfire generation with DMDZAG available, case 1" 2 "Misfire generation with DMDZAG available, case 2" /end COMPU_VTAB
/begin COMPU_METHOD SY_DOPZW_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF SY_DOPZW_Compu /end COMPU_METHOD
/begin COMPU_VTAB SY_DOPZW_Compu "" TAB_VERB 2 0 "keine doppelte Zündausgabe aktiv" 1 "doppelte Zündausgabe aktiv" /end COMPU_VTAB
/begin COMPU_METHOD SY_DSLSZP_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF SY_DSLSZP_Compu /end COMPU_METHOD
/begin COMPU_VTAB SY_DSLSZP_Compu "" TAB_VERB 2 0 "False" 1 "True" /end COMPU_VTAB
/begin COMPU_METHOD SY_DSPACE_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF SY_DSPACE_Compu /end COMPU_METHOD
/begin COMPU_VTAB SY_DSPACE_Compu "" TAB_VERB 2 0 "False" 1 "True" /end COMPU_VTAB
/begin COMPU_METHOD SY_DSS_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF SY_DSS_Compu /end COMPU_METHOD
/begin COMPU_VTAB SY_DSS_Compu "" TAB_VERB 2 0 "kein Drucksensor im Saugrohr verbaut" 1 "Drucksensor im Saugrohr verbaut" /end COMPU_VTAB
/begin COMPU_METHOD SY_DSU_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF SY_DSU_Compu /end COMPU_METHOD
/begin COMPU_VTAB SY_DSU_Compu "" TAB_VERB 2 0 "kein Umgebungsdrucksensor verbaut" 1 "Umgebungsdrucksensor verbaut" /end COMPU_VTAB
/begin COMPU_METHOD SY_DYLSEVAL_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF SY_DYLSEVAL_Compu /end COMPU_METHOD
/begin COMPU_VTAB SY_DYLSEVAL_Compu "" TAB_VERB 2 0 "False" 1 "True" /end COMPU_VTAB
/begin COMPU_METHOD SY_EGAS_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF SY_EGAS_Compu /end COMPU_METHOD
/begin COMPU_VTAB SY_EGAS_Compu "" TAB_VERB 2 0 "kein E-GAS System" 1 "E-GAS System" /end COMPU_VTAB
/begin COMPU_METHOD SY_EKPRMK_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF SY_EKPRMK_Compu /end COMPU_METHOD
/begin COMPU_VTAB SY_EKPRMK_Compu "" TAB_VERB 2 0 "keine anderen mitversorgten Komponenten oder ME9" 1 "nur ME7: mit anderen mitversorgten Komponenten" /end COMPU_VTAB
/begin COMPU_METHOD SY_ESDFPMN_Compu "" RAT_FUNC "%6.2" "" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD SY_EXCWM_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF SY_EXCWM_Compu /end COMPU_METHOD
/begin COMPU_VTAB SY_EXCWM_Compu "" TAB_VERB 2 0 "NO_CONDENSE_WAT" 1 "CONDENSE_WAT_FLUIDTRANS" /end COMPU_VTAB
/begin COMPU_METHOD SY_FABE_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF SY_FABE_Compu /end COMPU_METHOD
/begin COMPU_VTAB SY_FABE_Compu "" TAB_VERB 2 0 "shortened EOL-test unavailable" 1 "shortened EOL-test available" /end COMPU_VTAB
/begin COMPU_METHOD SY_FFV_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF SY_FFV_Compu /end COMPU_METHOD
/begin COMPU_VTAB SY_FFV_Compu "" TAB_VERB 2 0 "kein flexible fuel Fahrzeug" 1 "flexible fuel Fahrzeug" /end COMPU_VTAB
/begin COMPU_METHOD SY_FFZ_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF SY_FFZ_Compu /end COMPU_METHOD
/begin COMPU_VTAB SY_FFZ_Compu "" TAB_VERB 2 0 "keine Funkenbandzündung" 1 "Funkenbandzündung vorhanden" /end COMPU_VTAB
/begin COMPU_METHOD SY_FKAT2_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF SY_FKAT2_Compu /end COMPU_METHOD
/begin COMPU_VTAB SY_FKAT2_Compu "" TAB_VERB 2 0 "kein Frontkat Bank 2" 1 "Frontkat Bank 2 vorhanden" /end COMPU_VTAB
/begin COMPU_METHOD SY_FLOAKT_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF SY_FLOAKT_Compu /end COMPU_METHOD
/begin COMPU_VTAB SY_FLOAKT_Compu "" TAB_VERB 2 0 "False" 1 "True" /end COMPU_VTAB
/begin COMPU_METHOD SY_FSSZPA_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF SY_FSSZPA_Compu /end COMPU_METHOD
/begin COMPU_VTAB SY_FSSZPA_Compu "" TAB_VERB 2 0 "msvzpa_off" 1 "msvzpa_on" /end COMPU_VTAB
/begin COMPU_METHOD SY_FTIV_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF SY_FTIV_Compu /end COMPU_METHOD
/begin COMPU_VTAB SY_FTIV_Compu "" TAB_VERB 2 0 "FTIV_NOT_EXIST" 1 "FTIV_EXIST" /end COMPU_VTAB
/begin COMPU_METHOD SY_FZEATK_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF SY_FZEATK_Compu /end COMPU_METHOD
/begin COMPU_VTAB SY_FZEATK_Compu "" TAB_VERB 3 0 "Kein externer Aggregatekoordinator vorhanden" 1 "Standard-Aggregatekoordinator vorhanden" 2 "Spezieller Aggregatekoordinator vorhanden" /end COMPU_VTAB
/begin COMPU_METHOD SY_GRDWOF_Compu "" RAT_FUNC "%6.2" "" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD SY_GRDWRTB_Compu "" RAT_FUNC "%6.2" "" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD SY_GRDWRTC_Compu "" RAT_FUNC "%6.2" "" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD SY_GRDWRT_Compu "" RAT_FUNC "%6.2" "" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD SY_H2COFK_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF SY_H2COFK_Compu /end COMPU_METHOD
/begin COMPU_VTAB SY_H2COFK_Compu "" TAB_VERB 2 0 "False" 1 "True" /end COMPU_VTAB
/begin COMPU_METHOD SY_H2COHK_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF SY_H2COHK_Compu /end COMPU_METHOD
/begin COMPU_VTAB SY_H2COHK_Compu "" TAB_VERB 2 0 "False" 1 "True" /end COMPU_VTAB
/begin COMPU_METHOD SY_HDRFREQ_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF SY_HDRFREQ_Compu /end COMPU_METHOD
/begin COMPU_VTAB SY_HDRFREQ_Compu "" TAB_VERB 2 0 "HPCTL20MS" 1 "HPCTL10MS" /end COMPU_VTAB
/begin COMPU_METHOD SY_HDST_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF SY_HDST_Compu /end COMPU_METHOD
/begin COMPU_VTAB SY_HDST_Compu "" TAB_VERB 2 0 "kein HDST" 1 "HDST" /end COMPU_VTAB
/begin COMPU_METHOD SY_HEV_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF SY_HEV_Compu /end COMPU_METHOD
/begin COMPU_VTAB SY_HEV_Compu "" TAB_VERB 5 0 "HEV nicht vorhanden" 1 "serieller Hybridantrieb" 2 "Seriell-Paralleler Hybridantrieb" 3 "Leistungsverzweigender Hybridantrieb" 4 "Paralleler Hybridantrieb" /end COMPU_VTAB
/begin COMPU_METHOD SY_HFM_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF SY_HFM_Compu /end COMPU_METHOD
/begin COMPU_VTAB SY_HFM_Compu "" TAB_VERB 3 0 "kein HFM verbaut" 1 "HFM verbaut (vor Verdichter)" 2 "HFM verbaut (nach Verdichter)" /end COMPU_VTAB
/begin COMPU_METHOD SY_HLSFFET_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF SY_HLSFFET_Compu /end COMPU_METHOD
/begin COMPU_VTAB SY_HLSFFET_Compu "" TAB_VERB 2 0 "Keine FET-Endstufe Sondenheiz. hinter Front-Kat" 1 "FET-Endstufe Sondenheiz. hinter Front-Kat" /end COMPU_VTAB
/begin COMPU_METHOD SY_HLSHFET_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF SY_HLSHFET_Compu /end COMPU_METHOD
/begin COMPU_VTAB SY_HLSHFET_Compu "" TAB_VERB 2 0 "keine FET-Endstufe vorhanden" 1 "FET-Endstufe vorhanden" /end COMPU_VTAB
/begin COMPU_METHOD SY_HLSVFET_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF SY_HLSVFET_Compu /end COMPU_METHOD
/begin COMPU_VTAB SY_HLSVFET_Compu "" TAB_VERB 2 0 "FALSE" 1 "TRUE" /end COMPU_VTAB
/begin COMPU_METHOD SY_HMB_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF SY_HMB_Compu /end COMPU_METHOD
/begin COMPU_VTAB SY_HMB_Compu "" TAB_VERB 3 0 "No HMB" 1 "CDA" 2 "BDA" /end COMPU_VTAB
/begin COMPU_METHOD SY_HMM_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF SY_HMM_Compu /end COMPU_METHOD
/begin COMPU_VTAB SY_HMM_Compu "" TAB_VERB 2 0 "kein HMM-Betrieb vorhanden" 1 "HMM-Betrieb vorhanden" /end COMPU_VTAB
/begin COMPU_METHOD SY_ICLSUIP_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF SY_ICLSUIP_Compu /end COMPU_METHOD
/begin COMPU_VTAB SY_ICLSUIP_Compu "" TAB_VERB 2 0 "0" 1 "1" /end COMPU_VTAB
/begin COMPU_METHOD SY_IGICCH10_Compu "" RAT_FUNC "%6.2" "" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD SY_IGICCH11_Compu "" RAT_FUNC "%6.2" "" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD SY_IGICCH12_Compu "" RAT_FUNC "%6.2" "" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD SY_IGICCH1_Compu "" RAT_FUNC "%6.2" "" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD SY_IGICCH2_Compu "" RAT_FUNC "%6.2" "" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD SY_IGICCH3_Compu "" RAT_FUNC "%6.2" "" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD SY_IGICCH4_Compu "" RAT_FUNC "%6.2" "" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD SY_IGICCH5_Compu "" RAT_FUNC "%6.2" "" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD SY_IGICCH6_Compu "" RAT_FUNC "%6.2" "" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD SY_IGICCH7_Compu "" RAT_FUNC "%6.2" "" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD SY_IGICCH8_Compu "" RAT_FUNC "%6.2" "" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD SY_IGICCH9_Compu "" RAT_FUNC "%6.2" "" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD SY_IGIFLAG_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF SY_IGIFLAG_Compu /end COMPU_METHOD
/begin COMPU_VTAB SY_IGIFLAG_Compu "" TAB_VERB 2 0 "False" 1 "True" /end COMPU_VTAB
/begin COMPU_METHOD SY_IGNCHN10_Compu "" RAT_FUNC "%6.2" "" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD SY_IGNCHN11_Compu "" RAT_FUNC "%6.2" "" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD SY_IGNCHN12_Compu "" RAT_FUNC "%6.2" "" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD SY_IGNCHN1_Compu "" RAT_FUNC "%6.2" "" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD SY_IGNCHN2_Compu "" RAT_FUNC "%6.2" "" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD SY_IGNCHN3_Compu "" RAT_FUNC "%6.2" "" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/end MODULE
/end PROJECT
