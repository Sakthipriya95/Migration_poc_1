ASAP2_VERSION 1 4
/begin PROJECT MED1734_Flx_G1 "MEDC17_Core"
/begin HEADER "" VERSION "MED1734_Flx_01" PROJECT_NO MED1734_Flx_G1 /end HEADER
/begin MODULE DIM ""
/begin MOD_COMMON "" BYTE_ORDER MSB_LAST ALIGNMENT_BYTE 1 ALIGNMENT_WORD 2 ALIGNMENT_LONG 4 ALIGNMENT_FLOAT32_IEEE 4 /end MOD_COMMON
/begin CHARACTERISTIC DDRC_DurDeb.Com_tiCANG4_HDL13TODebOk_C "DDRC / Duration of healing debouncing for check DFC_ComCANG4_HDL13TO" VALUE 0x80282A18 Val_Wu16 655350.0 DDRCTime_ms 0.00 655350.0 FORMAT "%8.1" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.Com_tiCANG4_HDL13TODebDef_C "DDRC / Duration of defect debouncing for check DFC_ComCANG4_HDL13TO" VALUE 0x80282A1A Val_Wu16 655350.0 DDRCTime_ms 0.00 655350.0 FORMAT "%8.1" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.MonUMinSupply2DebOk_C "DDRC / Duration of defect debouncing for check DFC_MonUMinSupply2DebOkC" VALUE 0x80282A1C Val_Wu16 655350.0 DDRCTime_ms 0.00 655350.0 FORMAT "%8.1" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.MonUMinSupply2DebDef_C "DDRC / Duration of defect debouncing for check DFC_MonUMinSupply2DebDefC" VALUE 0x80282A1E Val_Wu16 655350.0 DDRCTime_ms 0.00 655350.0 FORMAT "%8.1" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.BusDiag_BusOff_tiBusOffNodeDDebOk_C "DDRC / Duration of healing debouncing for check DFC_BusDiagBusOffNodeD" VALUE 0x80282A20 Val_Wu16 655350.0 DDRCTime_ms 0.00 655350.0 FORMAT "%8.1" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.BusDiag_BusOff_tiBusOffNodeDDebDef_C "DDRC / Duration of defect debouncing for check DFC_BusDiagBusOffNodeD" VALUE 0x80282A22 Val_Wu16 655350.0 DDRCTime_ms 0.00 655350.0 FORMAT "%8.1" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.Com_tiCANG4_HDL15TODebOk_C "DDRC / Duration of healing debouncing for check DFC_ComCANG4_HDL15TO" VALUE 0x80282A24 Val_Wu16 655350.0 DDRCTime_ms 0.00 655350.0 FORMAT "%8.1" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.Com_tiCANG4_HDL15TODebDef_C "DDRC / Duration of defect debouncing for check DFC_ComCANG4_HDL15TO" VALUE 0x80282A26 Val_Wu16 655350.0 DDRCTime_ms 0.00 655350.0 FORMAT "%8.1" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.Com_tiCANG3_HDL16TODebOk_C "DDRC / Duration of healing debouncing for check DFC_ComCANG3_HDL16TO" VALUE 0x80282A28 Val_Wu16 655350.0 DDRCTime_ms 0.00 655350.0 FORMAT "%8.1" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.Com_tiCANG3_HDL16TODebDef_C "DDRC / Duration of defect debouncing for check DFC_ComCANG3_HDL16TO" VALUE 0x80282A2A Val_Wu16 655350.0 DDRCTime_ms 0.00 655350.0 FORMAT "%8.1" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.Com_tiCANG3_HDL19TODebOk_C "DDRC / Duration of healing debouncing for check DFC_ComCANG3_HDL19TO" VALUE 0x80282A2C Val_Wu16 655350.0 DDRCTime_ms 0.00 655350.0 FORMAT "%8.1" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.Com_tiCANG3_HDL19TODebDef_C "DDRC / Duration of defect debouncing for check DFC_ComCANG3_HDL19TO" VALUE 0x80282A2E Val_Wu16 655350.0 DDRCTime_ms 0.00 655350.0 FORMAT "%8.1" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.Com_tiCANG1_HDL13TODebOk_C "DDRC / Duration of healing debouncing for check DFC_ComCANG1_HDL13TO" VALUE 0x80282A30 Val_Wu16 655350.0 DDRCTime_ms 0.00 655350.0 FORMAT "%8.1" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.Com_tiCANG1_HDL13TODebDef_C "DDRC / Duration of defect debouncing for check DFC_ComCANG1_HDL13TO" VALUE 0x80282A32 Val_Wu16 655350.0 DDRCTime_ms 0.00 655350.0 FORMAT "%8.1" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.BusDiag_BusOff_tiErrPasNodeDDebOk_C "DDRC / Duration of healing debouncing for check DFC_BusDiag_ErrPasNodeD" VALUE 0x80282A34 Val_Wu16 655350.0 DDRCTime_ms 0.00 655350.0 FORMAT "%8.1" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.BusDiag_BusOff_tiErrPasNodeDDebDef_C "DDRC / Duration of defect debouncing for check DFC_BusDiag_ErrPasNodeD" VALUE 0x80282A36 Val_Wu16 655350.0 DDRCTime_ms 0.00 655350.0 FORMAT "%8.1" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.SSpMon1DebOk_C "DDRC / Duration of defect debouncing for check DFC_SSpMon1DebOkC" VALUE 0x80282A38 Val_Wu16 655350.0 DDRCTime_ms 0.00 655350.0 FORMAT "%8.1" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.SSpMon1DebDef_C "DDRC / Duration of defect debouncing for check DFC_SSpMon1DebDefC" VALUE 0x80282A3A Val_Wu16 655350.0 DDRCTime_ms 0.00 655350.0 FORMAT "%8.1" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.Com_tiCANG4_HDL11TODebOk_C "DDRC / Duration of healing debouncing for check DFC_ComCANG4_HDL11TO" VALUE 0x80282A3C Val_Wu16 655350.0 DDRCTime_ms 0.00 655350.0 FORMAT "%8.1" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.Com_tiCANG4_HDL11TODebDef_C "DDRC / Duration of defect debouncing for check DFC_ComCANG4_HDL11TO" VALUE 0x80282A3E Val_Wu16 655350.0 DDRCTime_ms 0.00 655350.0 FORMAT "%8.1" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.Com_tiCANG4_HDL7TODebOk_C "DDRC / Duration of healing debouncing for check DFC_ComCANG4_HDL7TO" VALUE 0x80282A40 Val_Wu16 655350.0 DDRCTime_ms 0.00 655350.0 FORMAT "%8.1" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.Com_tiCANG4_HDL7TODebDef_C "DDRC / Duration of defect debouncing for check DFC_ComCANG4_HDL7TO" VALUE 0x80282A42 Val_Wu16 655350.0 DDRCTime_ms 0.00 655350.0 FORMAT "%8.1" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.Com_tiCANG4_HDL18TODebOk_C "DDRC / Duration of healing debouncing for check DFC_ComCANG4_HDL18TO" VALUE 0x80282A44 Val_Wu16 655350.0 DDRCTime_ms 0.00 655350.0 FORMAT "%8.1" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.Com_tiCANG4_HDL18TODebDef_C "DDRC / Duration of defect debouncing for check DFC_ComCANG4_HDL18TO" VALUE 0x80282A46 Val_Wu16 655350.0 DDRCTime_ms 0.00 655350.0 FORMAT "%8.1" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.SSpMon2OVDebOk_C "DDRC / Duration of defect debouncing for check DFC_SSpMon2OVDebOkC" VALUE 0x80282A48 Val_Wu16 655350.0 DDRCTime_ms 0.00 655350.0 FORMAT "%8.1" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.SSpMon2OVDebDef_C "DDRC / Duration of defect debouncing for check DFC_SSpMon2OVDebDefC" VALUE 0x80282A4A Val_Wu16 655350.0 DDRCTime_ms 0.00 655350.0 FORMAT "%8.1" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.Com_tiCANG2_HDL19TODebOk_C "DDRC / Duration of healing debouncing for check DFC_ComCANG2_HDL19TO" VALUE 0x80282A4C Val_Wu16 655350.0 DDRCTime_ms 0.00 655350.0 FORMAT "%8.1" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.Com_tiCANG2_HDL19TODebDef_C "DDRC / Duration of defect debouncing for check DFC_ComCANG2_HDL19TO" VALUE 0x80282A4E Val_Wu16 655350.0 DDRCTime_ms 0.00 655350.0 FORMAT "%8.1" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.MonUMinSupply1DebOk_C "DDRC / Duration of defect debouncing for check DFC_MonUMinSupply1DebOkC" VALUE 0x80282A50 Val_Wu16 655350.0 DDRCTime_ms 0.00 655350.0 FORMAT "%8.1" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.MonUMinSupply1DebDef_C "DDRC / Duration of defect debouncing for check DFC_MonUMinSupply1DebDefC" VALUE 0x80282A52 Val_Wu16 655350.0 DDRCTime_ms 0.00 655350.0 FORMAT "%8.1" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.Com_tiCANG2_HDL17TODebOk_C "DDRC / Duration of healing debouncing for check DFC_ComCANG2_HDL17TO" VALUE 0x80282A54 Val_Wu16 655350.0 DDRCTime_ms 0.00 655350.0 FORMAT "%8.1" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.Com_tiCANG2_HDL17TODebDef_C "DDRC / Duration of defect debouncing for check DFC_ComCANG2_HDL17TO" VALUE 0x80282A56 Val_Wu16 655350.0 DDRCTime_ms 0.00 655350.0 FORMAT "%8.1" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.Com_tiCANG1_HDL20TODebOk_C "DDRC / Duration of healing debouncing for check DFC_ComCANG1_HDL20TO" VALUE 0x80282A58 Val_Wu16 655350.0 DDRCTime_ms 0.00 655350.0 FORMAT "%8.1" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.Com_tiCANG1_HDL20TODebDef_C "DDRC / Duration of defect debouncing for check DFC_ComCANG1_HDL20TO" VALUE 0x80282A5A Val_Wu16 655350.0 DDRCTime_ms 0.00 655350.0 FORMAT "%8.1" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.Com_tiCANG1_HDL4TODebOk_C "DDRC / Duration of healing debouncing for check DFC_ComCANG1_HDL4TO" VALUE 0x80282A5C Val_Wu16 655350.0 DDRCTime_ms 0.00 655350.0 FORMAT "%8.1" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.Com_tiCANG1_HDL4TODebDef_C "DDRC / Duration of defect debouncing for check DFC_ComCANG1_HDL4TO" VALUE 0x80282A5E Val_Wu16 655350.0 DDRCTime_ms 0.00 655350.0 FORMAT "%8.1" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.CY320_tiSpiComErrorDebOk_C "DDRC / Duration of healing debouncing for check DFC_CY320SpiComError" VALUE 0x80282A60 Val_Wu16 655350.0 DDRCTime_ms 0.00 655350.0 FORMAT "%8.1" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.CY320_tiSpiComErrorDebDef_C "DDRC / Duration of defect debouncing for check DFC_CY320SpiComError" VALUE 0x80282A62 Val_Wu16 655350.0 DDRCTime_ms 0.00 655350.0 FORMAT "%8.1" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.Com_tiCANG4_HDL8TODebOk_C "DDRC / Duration of healing debouncing for check DFC_ComCANG4_HDL8TO" VALUE 0x80282A64 Val_Wu16 655350.0 DDRCTime_ms 0.00 655350.0 FORMAT "%8.1" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.Com_tiCANG4_HDL8TODebDef_C "DDRC / Duration of defect debouncing for check DFC_ComCANG4_HDL8TO" VALUE 0x80282A66 Val_Wu16 655350.0 DDRCTime_ms 0.00 655350.0 FORMAT "%8.1" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.Com_tiCANG3_HDL1TODebOk_C "DDRC / Duration of healing debouncing for check DFC_ComCANG3_HDL1TO" VALUE 0x80282A68 Val_Wu16 655350.0 DDRCTime_ms 0.00 655350.0 FORMAT "%8.1" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.Com_tiCANG3_HDL1TODebDef_C "DDRC / Duration of defect debouncing for check DFC_ComCANG3_HDL1TO" VALUE 0x80282A6A Val_Wu16 655350.0 DDRCTime_ms 0.00 655350.0 FORMAT "%8.1" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.MonUMaxSupply2DebOk_C "DDRC / Duration of defect debouncing for check DFC_MonUMaxSupply2DebOkC" VALUE 0x80282A6C Val_Wu16 655350.0 DDRCTime_ms 0.00 655350.0 FORMAT "%8.1" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.MonUMaxSupply2DebDef_C "DDRC / Duration of defect debouncing for check DFC_MonUMaxSupply2DebDefC" VALUE 0x80282A6E Val_Wu16 655350.0 DDRCTime_ms 0.00 655350.0 FORMAT "%8.1" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.Com_tiCANG4_HDL1TODebOk_C "DDRC / Duration of healing debouncing for check DFC_ComCANG4_HDL1TO" VALUE 0x80282A70 Val_Wu16 655350.0 DDRCTime_ms 0.00 655350.0 FORMAT "%8.1" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.Com_tiCANG4_HDL1TODebDef_C "DDRC / Duration of defect debouncing for check DFC_ComCANG4_HDL1TO" VALUE 0x80282A72 Val_Wu16 655350.0 DDRCTime_ms 0.00 655350.0 FORMAT "%8.1" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.BusDiag_BusOff_tiErrPasNodeADebOk_C "DDRC / Duration of healing debouncing for check DFC_BusDiag_ErrPasNodeA" VALUE 0x80282A74 Val_Wu16 655350.0 DDRCTime_ms 0.00 655350.0 FORMAT "%8.1" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.BusDiag_BusOff_tiErrPasNodeADebDef_C "DDRC / Duration of defect debouncing for check DFC_BusDiag_ErrPasNodeA" VALUE 0x80282A76 Val_Wu16 655350.0 DDRCTime_ms 0.00 655350.0 FORMAT "%8.1" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.IgnClPs_numIgnCoilOpen4DebOk_C "DDRC / Duration of healing debouncing for check DFC_IgnClPsnumIgnCoilOpen4" VALUE 0x80282A78 Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.IgnClPs_numIgnCoilOpen4DebDef_C "DDRC / Duration of defect debouncing for check DFC_IgnClPsnumIgnCoilOpen4" VALUE 0x80282A7A Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.IgnClPs_numDevInitErr1DebOk_C "DDRC / Duration of healing debouncing for check DFC_IgnClPsnumDevInitErr1" VALUE 0x80282A7C Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.IgnClPs_numDevInitErr1DebDef_C "DDRC / Duration of defect debouncing for check DFC_IgnClPsnumDevInitErr1" VALUE 0x80282A7E Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.IgnClPs_numOpenLoad7DebOk_C "DDRC / Duration of healing debouncing for check DFC_IgnClPsnumOpenLoad7" VALUE 0x80282A80 Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.IgnClPs_numOpenLoad7DebDef_C "DDRC / Duration of defect debouncing for check DFC_IgnClPsnumOpenLoad7" VALUE 0x80282A82 Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.IgnClPs_numDevIdentErr1DebOk_C "DDRC / Duration of healing debouncing for check DFC_IgnClPsnumDevIdentErr1" VALUE 0x80282A84 Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.IgnClPs_numDevIdentErr1DebDef_C "DDRC / Duration of defect debouncing for check DFC_IgnClPsnumDevIdentErr1" VALUE 0x80282A86 Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.IgnClPs_numOpenLoad5DebOk_C "DDRC / Duration of healing debouncing for check DFC_IgnClPsnumOpenLoad5" VALUE 0x80282A88 Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.IgnClPs_numOpenLoad5DebDef_C "DDRC / Duration of defect debouncing for check DFC_IgnClPsnumOpenLoad5" VALUE 0x80282A8A Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.IgnClPs_numShCirGnd4DebOk_C "DDRC / Duration of healing debouncing for check DFC_IgnClPsnumShCirGnd4" VALUE 0x80282A8C Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.IgnClPs_numShCirGnd4DebDef_C "DDRC / Duration of defect debouncing for check DFC_IgnClPsnumShCirGnd4" VALUE 0x80282A8E Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.MfPsDia_numShCirGndDebOk_C "DDRC / Duration of healing debouncing for check DFC_MfPsDianumShCirGnd" VALUE 0x80282A90 Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.MfPsDia_numShCirGndDebDef_C "DDRC / Duration of defect debouncing for check DFC_MfPsDianumShCirGnd" VALUE 0x80282A92 Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.IgnClPs_numShCirBatt7DebOk_C "DDRC / Duration of healing debouncing for check DFC_IgnClPsnumShCirBatt7" VALUE 0x80282A94 Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.IgnClPs_numShCirBatt7DebDef_C "DDRC / Duration of defect debouncing for check DFC_IgnClPsnumShCirBatt7" VALUE 0x80282A96 Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.IgnClPs_numIgnCoilUnExpt3DebOk_C "DDRC / Duration of healing debouncing for check DFC_IgnClPsnumIgnCoilUnExpt3" VALUE 0x80282A98 Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.IgnClPs_numIgnCoilUnExpt3DebDef_C "DDRC / Duration of defect debouncing for check DFC_IgnClPsnumIgnCoilUnExpt3" VALUE 0x80282A9A Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.IgnClPs_numIgnCoilOpen0DebOk_C "DDRC / Duration of healing debouncing for check DFC_IgnClPsnumIgnCoilOpen0" VALUE 0x80282A9C Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.IgnClPs_numIgnCoilOpen0DebDef_C "DDRC / Duration of defect debouncing for check DFC_IgnClPsnumIgnCoilOpen0" VALUE 0x80282A9E Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.IgnClPs_numIgnCoilUnExpt6DebOk_C "DDRC / Duration of healing debouncing for check DFC_IgnClPsnumIgnCoilUnExpt6" VALUE 0x80282AA0 Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.IgnClPs_numIgnCoilUnExpt6DebDef_C "DDRC / Duration of defect debouncing for check DFC_IgnClPsnumIgnCoilUnExpt6" VALUE 0x80282AA2 Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.IgnClPs_numShCirBatt1DebOk_C "DDRC / Duration of healing debouncing for check DFC_IgnClPsnumShCirBatt1" VALUE 0x80282AA4 Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.IgnClPs_numShCirBatt1DebDef_C "DDRC / Duration of defect debouncing for check DFC_IgnClPsnumShCirBatt1" VALUE 0x80282AA6 Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.IgnClPs_numShCirGnd7DebOk_C "DDRC / Duration of healing debouncing for check DFC_IgnClPsnumShCirGnd7" VALUE 0x80282AA8 Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.IgnClPs_numShCirGnd7DebDef_C "DDRC / Duration of defect debouncing for check DFC_IgnClPsnumShCirGnd7" VALUE 0x80282AAA Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.IgnClPs_numIgnCoilUnExpt2DebOk_C "DDRC / Duration of healing debouncing for check DFC_IgnClPsnumIgnCoilUnExpt2" VALUE 0x80282AAC Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.IgnClPs_numIgnCoilUnExpt2DebDef_C "DDRC / Duration of defect debouncing for check DFC_IgnClPsnumIgnCoilUnExpt2" VALUE 0x80282AAE Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.IgnClPs_numIgnCoilShort0DebOk_C "DDRC / Duration of healing debouncing for check DFC_IgnClPsnumIgnCoilShort0" VALUE 0x80282AB0 Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.IgnClPs_numIgnCoilShort0DebDef_C "DDRC / Duration of defect debouncing for check DFC_IgnClPsnumIgnCoilShort0" VALUE 0x80282AB2 Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.IgnClPs_numShCirBatt0DebOk_C "DDRC / Duration of healing debouncing for check DFC_IgnClPsnumShCirBatt0" VALUE 0x80282AB4 Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.IgnClPs_numShCirBatt0DebDef_C "DDRC / Duration of defect debouncing for check DFC_IgnClPsnumShCirBatt0" VALUE 0x80282AB6 Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.IgnClPs_numIgnCoilOpen6DebOk_C "DDRC / Duration of healing debouncing for check DFC_IgnClPsnumIgnCoilOpen6" VALUE 0x80282AB8 Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.IgnClPs_numIgnCoilOpen6DebDef_C "DDRC / Duration of defect debouncing for check DFC_IgnClPsnumIgnCoilOpen6" VALUE 0x80282ABA Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.IgnClPs_numShCirBatt2DebOk_C "DDRC / Duration of healing debouncing for check DFC_IgnClPsnumShCirBatt2" VALUE 0x80282ABC Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.IgnClPs_numShCirBatt2DebDef_C "DDRC / Duration of defect debouncing for check DFC_IgnClPsnumShCirBatt2" VALUE 0x80282ABE Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.IgnClPs_numIgnCoilShort6DebOk_C "DDRC / Duration of healing debouncing for check DFC_IgnClPsnumIgnCoilShort6" VALUE 0x80282AC0 Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.IgnClPs_numIgnCoilShort6DebDef_C "DDRC / Duration of defect debouncing for check DFC_IgnClPsnumIgnCoilShort6" VALUE 0x80282AC2 Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.MfPsDia_numShCirGnd2DebOk_C "DDRC / Duration of healing debouncing for check DFC_MfPsDianumShCirGnd2" VALUE 0x80282AC4 Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.MfPsDia_numShCirGnd2DebDef_C "DDRC / Duration of defect debouncing for check DFC_MfPsDianumShCirGnd2" VALUE 0x80282AC6 Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.IgnClPs_numDevOscErr1DebOk_C "DDRC / Duration of healing debouncing for check DFC_IgnClPsnumDevOscErr1" VALUE 0x80282AC8 Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.IgnClPs_numDevOscErr1DebDef_C "DDRC / Duration of defect debouncing for check DFC_IgnClPsnumDevOscErr1" VALUE 0x80282ACA Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.IgnClPs_numOpenLoad2DebOk_C "DDRC / Duration of healing debouncing for check DFC_IgnClPsnumOpenLoad2" VALUE 0x80282ACC Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.IgnClPs_numOpenLoad2DebDef_C "DDRC / Duration of defect debouncing for check DFC_IgnClPsnumOpenLoad2" VALUE 0x80282ACE Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.IgnClPs_numIgnCoilShort2DebOk_C "DDRC / Duration of healing debouncing for check DFC_IgnClPsnumIgnCoilShort2" VALUE 0x80282AD0 Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.IgnClPs_numIgnCoilShort2DebDef_C "DDRC / Duration of defect debouncing for check DFC_IgnClPsnumIgnCoilShort2" VALUE 0x80282AD2 Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.IgnClPs_numDevSpiErr1DebOk_C "DDRC / Duration of healing debouncing for check DFC_IgnClPsnumDevSpiErr1" VALUE 0x80282AD4 Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.IgnClPs_numDevSpiErr1DebDef_C "DDRC / Duration of defect debouncing for check DFC_IgnClPsnumDevSpiErr1" VALUE 0x80282AD6 Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.IgnClPs_numIgnCoilOpen2DebOk_C "DDRC / Duration of healing debouncing for check DFC_IgnClPsnumIgnCoilOpen2" VALUE 0x80282AD8 Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.IgnClPs_numIgnCoilOpen2DebDef_C "DDRC / Duration of defect debouncing for check DFC_IgnClPsnumIgnCoilOpen2" VALUE 0x80282ADA Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.IgnClPs_numIgnCoilUnExpt0DebOk_C "DDRC / Duration of healing debouncing for check DFC_IgnClPsnumIgnCoilUnExpt0" VALUE 0x80282ADC Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.IgnClPs_numIgnCoilUnExpt0DebDef_C "DDRC / Duration of defect debouncing for check DFC_IgnClPsnumIgnCoilUnExpt0" VALUE 0x80282ADE Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.IgnClPs_numShCirGnd0DebOk_C "DDRC / Duration of healing debouncing for check DFC_IgnClPsnumShCirGnd0" VALUE 0x80282AE0 Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.IgnClPs_numShCirGnd0DebDef_C "DDRC / Duration of defect debouncing for check DFC_IgnClPsnumShCirGnd0" VALUE 0x80282AE2 Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.IgnClPs_numShCirGnd2DebOk_C "DDRC / Duration of healing debouncing for check DFC_IgnClPsnumShCirGnd2" VALUE 0x80282AE4 Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.IgnClPs_numShCirGnd2DebDef_C "DDRC / Duration of defect debouncing for check DFC_IgnClPsnumShCirGnd2" VALUE 0x80282AE6 Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.IgnClPs_numIgnCoilUnExpt7DebOk_C "DDRC / Duration of healing debouncing for check DFC_IgnClPsnumIgnCoilUnExpt7" VALUE 0x80282AE8 Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.IgnClPs_numIgnCoilUnExpt7DebDef_C "DDRC / Duration of defect debouncing for check DFC_IgnClPsnumIgnCoilUnExpt7" VALUE 0x80282AEA Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.IgnClPs_numDevSpiErr2DebOk_C "DDRC / Duration of healing debouncing for check DFC_IgnClPsnumDevSpiErr2" VALUE 0x80282AEC Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.IgnClPs_numDevSpiErr2DebDef_C "DDRC / Duration of defect debouncing for check DFC_IgnClPsnumDevSpiErr2" VALUE 0x80282AEE Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.MfPsDia_numOpenLoad2DebOk_C "DDRC / Duration of healing debouncing for check DFC_MfPsDianumOpenLoad2" VALUE 0x80282AF0 Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.MfPsDia_numOpenLoad2DebDef_C "DDRC / Duration of defect debouncing for check DFC_MfPsDianumOpenLoad2" VALUE 0x80282AF2 Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.MfPsDia_numShCirBattDebOk_C "DDRC / Duration of healing debouncing for check DFC_MfPsDianumShCirBatt" VALUE 0x80282AF4 Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.MfPsDia_numShCirBattDebDef_C "DDRC / Duration of defect debouncing for check DFC_MfPsDianumShCirBatt" VALUE 0x80282AF6 Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.IgnClPs_numIgnCoilOpen7DebOk_C "DDRC / Duration of healing debouncing for check DFC_IgnClPsnumIgnCoilOpen7" VALUE 0x80282AF8 Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.IgnClPs_numIgnCoilOpen7DebDef_C "DDRC / Duration of defect debouncing for check DFC_IgnClPsnumIgnCoilOpen7" VALUE 0x80282AFA Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.MfPsDia_numShCirBatt2DebOk_C "DDRC / Duration of healing debouncing for check DFC_MfPsDianumShCirBatt2" VALUE 0x80282AFC Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.MfPsDia_numShCirBatt2DebDef_C "DDRC / Duration of defect debouncing for check DFC_MfPsDianumShCirBatt2" VALUE 0x80282AFE Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.IgnClPs_numShCirBatt6DebOk_C "DDRC / Duration of healing debouncing for check DFC_IgnClPsnumShCirBatt6" VALUE 0x80282B00 Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.IgnClPs_numShCirBatt6DebDef_C "DDRC / Duration of defect debouncing for check DFC_IgnClPsnumShCirBatt6" VALUE 0x80282B02 Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.IgnClPs_numIgnCoilUnExpt4DebOk_C "DDRC / Duration of healing debouncing for check DFC_IgnClPsnumIgnCoilUnExpt4" VALUE 0x80282B04 Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.IgnClPs_numIgnCoilUnExpt4DebDef_C "DDRC / Duration of defect debouncing for check DFC_IgnClPsnumIgnCoilUnExpt4" VALUE 0x80282B06 Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.IgnClPs_numIgnCoilOpen5DebOk_C "DDRC / Duration of healing debouncing for check DFC_IgnClPsnumIgnCoilOpen5" VALUE 0x80282B08 Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.IgnClPs_numIgnCoilOpen5DebDef_C "DDRC / Duration of defect debouncing for check DFC_IgnClPsnumIgnCoilOpen5" VALUE 0x80282B0A Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.IgnClPs_numShCirBatt4DebOk_C "DDRC / Duration of healing debouncing for check DFC_IgnClPsnumShCirBatt4" VALUE 0x80282B0C Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.IgnClPs_numShCirBatt4DebDef_C "DDRC / Duration of defect debouncing for check DFC_IgnClPsnumShCirBatt4" VALUE 0x80282B0E Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.IgnClPs_numIgnCoilOpen1DebOk_C "DDRC / Duration of healing debouncing for check DFC_IgnClPsnumIgnCoilOpen1" VALUE 0x80282B10 Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.IgnClPs_numIgnCoilOpen1DebDef_C "DDRC / Duration of defect debouncing for check DFC_IgnClPsnumIgnCoilOpen1" VALUE 0x80282B12 Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.IgnClPs_numShCirBatt3DebOk_C "DDRC / Duration of healing debouncing for check DFC_IgnClPsnumShCirBatt3" VALUE 0x80282B14 Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.IgnClPs_numShCirBatt3DebDef_C "DDRC / Duration of defect debouncing for check DFC_IgnClPsnumShCirBatt3" VALUE 0x80282B16 Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.IgnClPs_numDevIdentErr2DebOk_C "DDRC / Duration of healing debouncing for check DFC_IgnClPsnumDevIdentErr2" VALUE 0x80282B18 Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.IgnClPs_numDevIdentErr2DebDef_C "DDRC / Duration of defect debouncing for check DFC_IgnClPsnumDevIdentErr2" VALUE 0x80282B1A Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.IgnClPs_numShCirGnd5DebOk_C "DDRC / Duration of healing debouncing for check DFC_IgnClPsnumShCirGnd5" VALUE 0x80282B1C Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.IgnClPs_numShCirGnd5DebDef_C "DDRC / Duration of defect debouncing for check DFC_IgnClPsnumShCirGnd5" VALUE 0x80282B1E Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.IgnClPs_numDevInitErr2DebOk_C "DDRC / Duration of healing debouncing for check DFC_IgnClPsnumDevInitErr2" VALUE 0x80282B20 Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.IgnClPs_numDevInitErr2DebDef_C "DDRC / Duration of defect debouncing for check DFC_IgnClPsnumDevInitErr2" VALUE 0x80282B22 Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.IgnClPs_numIgnCoilShort3DebOk_C "DDRC / Duration of healing debouncing for check DFC_IgnClPsnumIgnCoilShort3" VALUE 0x80282B24 Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.IgnClPs_numIgnCoilShort3DebDef_C "DDRC / Duration of defect debouncing for check DFC_IgnClPsnumIgnCoilShort3" VALUE 0x80282B26 Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.MfPsDia_numNonPlausDebOk_C "DDRC / Duration of healing debouncing for check DFC_MfPsDianumNonPlaus" VALUE 0x80282B28 Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.MfPsDia_numNonPlausDebDef_C "DDRC / Duration of defect debouncing for check DFC_MfPsDianumNonPlaus" VALUE 0x80282B2A Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.KnDet_numShCirDebOk_C "DDRC / Duration of healing debouncing for check DFC_KnDetnumShCir" VALUE 0x80282B2C Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.KnDet_numShCirDebDef_C "DDRC / Duration of defect debouncing for check DFC_KnDetnumShCir" VALUE 0x80282B2E Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.IgnClPs_numShCirGnd6DebOk_C "DDRC / Duration of healing debouncing for check DFC_IgnClPsnumShCirGnd6" VALUE 0x80282B30 Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.IgnClPs_numShCirGnd6DebDef_C "DDRC / Duration of defect debouncing for check DFC_IgnClPsnumShCirGnd6" VALUE 0x80282B32 Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.IgnClPs_numOpenLoad3DebOk_C "DDRC / Duration of healing debouncing for check DFC_IgnClPsnumOpenLoad3" VALUE 0x80282B34 Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.IgnClPs_numOpenLoad3DebDef_C "DDRC / Duration of defect debouncing for check DFC_IgnClPsnumOpenLoad3" VALUE 0x80282B36 Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.IgnClPs_numShCirBatt5DebOk_C "DDRC / Duration of healing debouncing for check DFC_IgnClPsnumShCirBatt5" VALUE 0x80282B38 Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.IgnClPs_numShCirBatt5DebDef_C "DDRC / Duration of defect debouncing for check DFC_IgnClPsnumShCirBatt5" VALUE 0x80282B3A Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.IgnClPs_numIgnCoilShort4DebOk_C "DDRC / Duration of healing debouncing for check DFC_IgnClPsnumIgnCoilShort4" VALUE 0x80282B3C Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.IgnClPs_numIgnCoilShort4DebDef_C "DDRC / Duration of defect debouncing for check DFC_IgnClPsnumIgnCoilShort4" VALUE 0x80282B3E Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.InjVlvPs_numComHDEVDebOk_C "DDRC / Duration of healing debouncing for check DFC_InjVlvPsnumComHDEV" VALUE 0x80282B40 Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.InjVlvPs_numComHDEVDebDef_C "DDRC / Duration of defect debouncing for check DFC_InjVlvPsnumComHDEV" VALUE 0x80282B42 Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.IgnClPs_numDevOscErr2DebOk_C "DDRC / Duration of healing debouncing for check DFC_IgnClPsnumDevOscErr2" VALUE 0x80282B44 Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.IgnClPs_numDevOscErr2DebDef_C "DDRC / Duration of defect debouncing for check DFC_IgnClPsnumDevOscErr2" VALUE 0x80282B46 Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.MfPsDia_numOpenLoadDebOk_C "DDRC / Duration of healing debouncing for check DFC_MfPsDianumOpenLoad" VALUE 0x80282B48 Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.MfPsDia_numOpenLoadDebDef_C "DDRC / Duration of defect debouncing for check DFC_MfPsDianumOpenLoad" VALUE 0x80282B4A Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.IgnClPs_numIgnCoilShort5DebOk_C "DDRC / Duration of healing debouncing for check DFC_IgnClPsnumIgnCoilShort5" VALUE 0x80282B4C Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.IgnClPs_numIgnCoilShort5DebDef_C "DDRC / Duration of defect debouncing for check DFC_IgnClPsnumIgnCoilShort5" VALUE 0x80282B4E Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.IgnClPs_numIgnCoilUnExpt5DebOk_C "DDRC / Duration of healing debouncing for check DFC_IgnClPsnumIgnCoilUnExpt5" VALUE 0x80282B50 Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.IgnClPs_numIgnCoilUnExpt5DebDef_C "DDRC / Duration of defect debouncing for check DFC_IgnClPsnumIgnCoilUnExpt5" VALUE 0x80282B52 Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.IgnClPs_numIgnCoilShort7DebOk_C "DDRC / Duration of healing debouncing for check DFC_IgnClPsnumIgnCoilShort7" VALUE 0x80282B54 Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.IgnClPs_numIgnCoilShort7DebDef_C "DDRC / Duration of defect debouncing for check DFC_IgnClPsnumIgnCoilShort7" VALUE 0x80282B56 Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.IgnClPs_numIgnCoilShort1DebOk_C "DDRC / Duration of healing debouncing for check DFC_IgnClPsnumIgnCoilShort1" VALUE 0x80282B58 Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.IgnClPs_numIgnCoilShort1DebDef_C "DDRC / Duration of defect debouncing for check DFC_IgnClPsnumIgnCoilShort1" VALUE 0x80282B5A Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.IgnClPs_numOpenLoad1DebOk_C "DDRC / Duration of healing debouncing for check DFC_IgnClPsnumOpenLoad1" VALUE 0x80282B5C Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.IgnClPs_numOpenLoad1DebDef_C "DDRC / Duration of defect debouncing for check DFC_IgnClPsnumOpenLoad1" VALUE 0x80282B5E Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.IgnClPs_numOpenLoad4DebOk_C "DDRC / Duration of healing debouncing for check DFC_IgnClPsnumOpenLoad4" VALUE 0x80282B60 Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.IgnClPs_numOpenLoad4DebDef_C "DDRC / Duration of defect debouncing for check DFC_IgnClPsnumOpenLoad4" VALUE 0x80282B62 Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.IgnClPs_numShCirGnd3DebOk_C "DDRC / Duration of healing debouncing for check DFC_IgnClPsnumShCirGnd3" VALUE 0x80282B64 Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.IgnClPs_numShCirGnd3DebDef_C "DDRC / Duration of defect debouncing for check DFC_IgnClPsnumShCirGnd3" VALUE 0x80282B66 Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.IgnClPs_numIgnCoilUnExpt1DebOk_C "DDRC / Duration of healing debouncing for check DFC_IgnClPsnumIgnCoilUnExpt1" VALUE 0x80282B68 Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.IgnClPs_numIgnCoilUnExpt1DebDef_C "DDRC / Duration of defect debouncing for check DFC_IgnClPsnumIgnCoilUnExpt1" VALUE 0x80282B6A Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.IgnClPs_numOpenLoad6DebOk_C "DDRC / Duration of healing debouncing for check DFC_IgnClPsnumOpenLoad6" VALUE 0x80282B6C Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.IgnClPs_numOpenLoad6DebDef_C "DDRC / Duration of defect debouncing for check DFC_IgnClPsnumOpenLoad6" VALUE 0x80282B6E Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.MfPsDia_numNonPlaus2DebOk_C "DDRC / Duration of healing debouncing for check DFC_MfPsDianumNonPlaus2" VALUE 0x80282B70 Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.MfPsDia_numNonPlaus2DebDef_C "DDRC / Duration of defect debouncing for check DFC_MfPsDianumNonPlaus2" VALUE 0x80282B72 Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.IgnClPs_numShCirGnd1DebOk_C "DDRC / Duration of healing debouncing for check DFC_IgnClPsnumShCirGnd1" VALUE 0x80282B74 Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.IgnClPs_numShCirGnd1DebDef_C "DDRC / Duration of defect debouncing for check DFC_IgnClPsnumShCirGnd1" VALUE 0x80282B76 Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.IgnClPs_numIgnCoilOpen3DebOk_C "DDRC / Duration of healing debouncing for check DFC_IgnClPsnumIgnCoilOpen3" VALUE 0x80282B78 Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.IgnClPs_numIgnCoilOpen3DebDef_C "DDRC / Duration of defect debouncing for check DFC_IgnClPsnumIgnCoilOpen3" VALUE 0x80282B7A Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.IgnClPs_numOpenLoad0DebOk_C "DDRC / Duration of healing debouncing for check DFC_IgnClPsnumOpenLoad0" VALUE 0x80282B7C Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_DurDeb.IgnClPs_numOpenLoad0DebDef_C "DDRC / Duration of defect debouncing for check DFC_IgnClPsnumOpenLoad0" VALUE 0x80282B7E Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_RatDeb.DevLib_tiBattULoUDRat_C "" VALUE 0x802836F0 Val_Wu8 3.00000000000 DDRC_Ratio 1.00000000000 4.00000000000 FORMAT "%13.11" /end CHARACTERISTIC
/begin CHARACTERISTIC DDRC_RatDeb.DevLib_tiBattUHiUDRat_C "" VALUE 0x802836F1 Val_Wu8 3.00000000000 DDRC_Ratio 1.00000000000 4.00000000000 FORMAT "%13.11" /end CHARACTERISTIC
/begin CHARACTERISTIC DevLib_DigOutDbgSig_C "" VALUE 0x802B9602 Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC Devlib_PsDisbl.facLowHysLo_C "" VALUE 0x802B9606 Kw_Ws16 1.000000 Fact 0.00 1.000000 FORMAT "%8.6" /end CHARACTERISTIC
/begin CHARACTERISTIC Devlib_PsDisbl.facLowHysHi_C "" VALUE 0x802B9608 Kw_Ws16 1.000000 Fact 0.00 1.000000 FORMAT "%8.6" /end CHARACTERISTIC
/begin CHARACTERISTIC Devlib_PsDisbl.facHighHysLo_C "" VALUE 0x802B960A Kw_Ws16 2.000000 Fact 1.000000 3.000000 FORMAT "%8.6" /end CHARACTERISTIC
/begin CHARACTERISTIC Devlib_PsDisbl.facHighHysHi_C "" VALUE 0x802B960C Kw_Ws16 2.000000 Fact 1.000000 3.000000 FORMAT "%8.6" /end CHARACTERISTIC
/begin CHARACTERISTIC DevLib_PWMOutDbgSig_C "" VALUE 0x802B9604 Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC Devlib_PwrStg.BattLoHysLo_C "" VALUE 0x802B960E Kw_Ws16 9000.000 Volt_Batt 3000.000 12000.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC Devlib_PwrStg.BattLoHysHi_C "" VALUE 0x802B9610 Kw_Ws16 9000.000 Volt_Batt 3000.000 12000.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC Devlib_PwrStg.BattHiHysLo_C "" VALUE 0x802B9612 Kw_Ws16 24000.00 Volt_Batt 12000.00 36000.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC Devlib_PwrStg.BattHiHysHi_C "" VALUE 0x802B9614 Kw_Ws16 24000.00 Volt_Batt 12000.00 36000.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_Unused_C "Behaviour control masks / " VALUE 0x80282B80 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" READ_ONLY /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_BusDiagBusOffErrPasNodeA_C "Behaviour control masks / Behaviour control masks of check DFC_BusDiagBusOffErrPasNodeA" VALUE 0x80282B82 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_BusDiagBusOffErrPasNodeB_C "Behaviour control masks / Behaviour control masks of check DFC_BusDiagBusOffErrPasNodeB" VALUE 0x80282B84 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_BusDiagBusOffErrPasNodeC_C "Behaviour control masks / Behaviour control masks of check DFC_BusDiagBusOffErrPasNodeC" VALUE 0x80282B86 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_BusDiagBusOffErrPasNodeD_C "Behaviour control masks / Behaviour control masks of check DFC_BusDiagBusOffErrPasNodeD" VALUE 0x80282B88 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_BusDiagBusOffNodeA_C "Behaviour control masks / Behaviour control masks of check DFC_BusDiagBusOffNodeA" VALUE 0x80282B8A Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_BusDiagBusOffNodeB_C "Behaviour control masks / Behaviour control masks of check DFC_BusDiagBusOffNodeB" VALUE 0x80282B8C Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_BusDiagBusOffNodeC_C "Behaviour control masks / Behaviour control masks of check DFC_BusDiagBusOffNodeC" VALUE 0x80282B8E Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_BusDiagBusOffNodeD_C "Behaviour control masks / Behaviour control masks of check DFC_BusDiagBusOffNodeD" VALUE 0x80282B90 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_ComCANG1_HDL0TO_C "Behaviour control masks / Behaviour control masks of check DFC_ComCANG1_HDL0TO" VALUE 0x80282B92 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_ComCANG1_HDL10TO_C "Behaviour control masks / Behaviour control masks of check DFC_ComCANG1_HDL10TO" VALUE 0x80282B94 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_ComCANG1_HDL11TO_C "Behaviour control masks / Behaviour control masks of check DFC_ComCANG1_HDL11TO" VALUE 0x80282B96 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_ComCANG1_HDL12TO_C "Behaviour control masks / Behaviour control masks of check DFC_ComCANG1_HDL12TO" VALUE 0x80282B98 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_ComCANG1_HDL13TO_C "Behaviour control masks / Behaviour control masks of check DFC_ComCANG1_HDL13TO" VALUE 0x80282B9A Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_ComCANG1_HDL14TO_C "Behaviour control masks / Behaviour control masks of check DFC_ComCANG1_HDL14TO" VALUE 0x80282B9C Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_ComCANG1_HDL15TO_C "Behaviour control masks / Behaviour control masks of check DFC_ComCANG1_HDL15TO" VALUE 0x80282B9E Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_ComCANG1_HDL16TO_C "Behaviour control masks / Behaviour control masks of check DFC_ComCANG1_HDL16TO" VALUE 0x80282BA0 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_ComCANG1_HDL17TO_C "Behaviour control masks / Behaviour control masks of check DFC_ComCANG1_HDL17TO" VALUE 0x80282BA2 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_ComCANG1_HDL18TO_C "Behaviour control masks / Behaviour control masks of check DFC_ComCANG1_HDL18TO" VALUE 0x80282BA4 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_ComCANG1_HDL19TO_C "Behaviour control masks / Behaviour control masks of check DFC_ComCANG1_HDL19TO" VALUE 0x80282BA6 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_ComCANG1_HDL1TO_C "Behaviour control masks / Behaviour control masks of check DFC_ComCANG1_HDL1TO" VALUE 0x80282BA8 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_ComCANG1_HDL20TO_C "Behaviour control masks / Behaviour control masks of check DFC_ComCANG1_HDL20TO" VALUE 0x80282BAA Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_ComCANG1_HDL21TO_C "Behaviour control masks / Behaviour control masks of check DFC_ComCANG1_HDL21TO" VALUE 0x80282BAC Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_ComCANG1_HDL22TO_C "Behaviour control masks / Behaviour control masks of check DFC_ComCANG1_HDL22TO" VALUE 0x80282BAE Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_ComCANG1_HDL23TO_C "Behaviour control masks / Behaviour control masks of check DFC_ComCANG1_HDL23TO" VALUE 0x80282BB0 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_ComCANG1_HDL24TO_C "Behaviour control masks / Behaviour control masks of check DFC_ComCANG1_HDL24TO" VALUE 0x80282BB2 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_ComCANG1_HDL2TO_C "Behaviour control masks / Behaviour control masks of check DFC_ComCANG1_HDL2TO" VALUE 0x80282BB4 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_ComCANG1_HDL3TO_C "Behaviour control masks / Behaviour control masks of check DFC_ComCANG1_HDL3TO" VALUE 0x80282BB6 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_ComCANG1_HDL4TO_C "Behaviour control masks / Behaviour control masks of check DFC_ComCANG1_HDL4TO" VALUE 0x80282BB8 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_ComCANG1_HDL5TO_C "Behaviour control masks / Behaviour control masks of check DFC_ComCANG1_HDL5TO" VALUE 0x80282BBA Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_ComCANG1_HDL6TO_C "Behaviour control masks / Behaviour control masks of check DFC_ComCANG1_HDL6TO" VALUE 0x80282BBC Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_ComCANG1_HDL7TO_C "Behaviour control masks / Behaviour control masks of check DFC_ComCANG1_HDL7TO" VALUE 0x80282BBE Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_ComCANG1_HDL8TO_C "Behaviour control masks / Behaviour control masks of check DFC_ComCANG1_HDL8TO" VALUE 0x80282BC0 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_ComCANG1_HDL9TO_C "Behaviour control masks / Behaviour control masks of check DFC_ComCANG1_HDL9TO" VALUE 0x80282BC2 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_ComCANG2_HDL0TO_C "Behaviour control masks / Behaviour control masks of check DFC_ComCANG2_HDL0TO" VALUE 0x80282BC4 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_ComCANG2_HDL10TO_C "Behaviour control masks / Behaviour control masks of check DFC_ComCANG2_HDL10TO" VALUE 0x80282BC6 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_ComCANG2_HDL11TO_C "Behaviour control masks / Behaviour control masks of check DFC_ComCANG2_HDL11TO" VALUE 0x80282BC8 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_ComCANG2_HDL12TO_C "Behaviour control masks / Behaviour control masks of check DFC_ComCANG2_HDL12TO" VALUE 0x80282BCA Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_ComCANG2_HDL13TO_C "Behaviour control masks / Behaviour control masks of check DFC_ComCANG2_HDL13TO" VALUE 0x80282BCC Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_ComCANG2_HDL14TO_C "Behaviour control masks / Behaviour control masks of check DFC_ComCANG2_HDL14TO" VALUE 0x80282BCE Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_ComCANG2_HDL15TO_C "Behaviour control masks / Behaviour control masks of check DFC_ComCANG2_HDL15TO" VALUE 0x80282BD0 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_ComCANG2_HDL16TO_C "Behaviour control masks / Behaviour control masks of check DFC_ComCANG2_HDL16TO" VALUE 0x80282BD2 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_ComCANG2_HDL17TO_C "Behaviour control masks / Behaviour control masks of check DFC_ComCANG2_HDL17TO" VALUE 0x80282BD4 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_ComCANG2_HDL18TO_C "Behaviour control masks / Behaviour control masks of check DFC_ComCANG2_HDL18TO" VALUE 0x80282BD6 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_ComCANG2_HDL19TO_C "Behaviour control masks / Behaviour control masks of check DFC_ComCANG2_HDL19TO" VALUE 0x80282BD8 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_ComCANG2_HDL1TO_C "Behaviour control masks / Behaviour control masks of check DFC_ComCANG2_HDL1TO" VALUE 0x80282BDA Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_ComCANG2_HDL20TO_C "Behaviour control masks / Behaviour control masks of check DFC_ComCANG2_HDL20TO" VALUE 0x80282BDC Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_ComCANG2_HDL21TO_C "Behaviour control masks / Behaviour control masks of check DFC_ComCANG2_HDL21TO" VALUE 0x80282BDE Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_ComCANG2_HDL22TO_C "Behaviour control masks / Behaviour control masks of check DFC_ComCANG2_HDL22TO" VALUE 0x80282BE0 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_ComCANG2_HDL23TO_C "Behaviour control masks / Behaviour control masks of check DFC_ComCANG2_HDL23TO" VALUE 0x80282BE2 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_ComCANG2_HDL24TO_C "Behaviour control masks / Behaviour control masks of check DFC_ComCANG2_HDL24TO" VALUE 0x80282BE4 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_ComCANG2_HDL2TO_C "Behaviour control masks / Behaviour control masks of check DFC_ComCANG2_HDL2TO" VALUE 0x80282BE6 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_ComCANG2_HDL3TO_C "Behaviour control masks / Behaviour control masks of check DFC_ComCANG2_HDL3TO" VALUE 0x80282BE8 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_ComCANG2_HDL4TO_C "Behaviour control masks / Behaviour control masks of check DFC_ComCANG2_HDL4TO" VALUE 0x80282BEA Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_ComCANG2_HDL5TO_C "Behaviour control masks / Behaviour control masks of check DFC_ComCANG2_HDL5TO" VALUE 0x80282BEC Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_ComCANG2_HDL6TO_C "Behaviour control masks / Behaviour control masks of check DFC_ComCANG2_HDL6TO" VALUE 0x80282BEE Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_ComCANG2_HDL7TO_C "Behaviour control masks / Behaviour control masks of check DFC_ComCANG2_HDL7TO" VALUE 0x80282BF0 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_ComCANG2_HDL8TO_C "Behaviour control masks / Behaviour control masks of check DFC_ComCANG2_HDL8TO" VALUE 0x80282BF2 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_ComCANG2_HDL9TO_C "Behaviour control masks / Behaviour control masks of check DFC_ComCANG2_HDL9TO" VALUE 0x80282BF4 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_ComCANG3_HDL0TO_C "Behaviour control masks / Behaviour control masks of check DFC_ComCANG3_HDL0TO" VALUE 0x80282BF6 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_ComCANG3_HDL10TO_C "Behaviour control masks / Behaviour control masks of check DFC_ComCANG3_HDL10TO" VALUE 0x80282BF8 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_ComCANG3_HDL11TO_C "Behaviour control masks / Behaviour control masks of check DFC_ComCANG3_HDL11TO" VALUE 0x80282BFA Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_ComCANG3_HDL12TO_C "Behaviour control masks / Behaviour control masks of check DFC_ComCANG3_HDL12TO" VALUE 0x80282BFC Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_ComCANG3_HDL13TO_C "Behaviour control masks / Behaviour control masks of check DFC_ComCANG3_HDL13TO" VALUE 0x80282BFE Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_ComCANG3_HDL14TO_C "Behaviour control masks / Behaviour control masks of check DFC_ComCANG3_HDL14TO" VALUE 0x80282C00 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_ComCANG3_HDL15TO_C "Behaviour control masks / Behaviour control masks of check DFC_ComCANG3_HDL15TO" VALUE 0x80282C02 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_ComCANG3_HDL16TO_C "Behaviour control masks / Behaviour control masks of check DFC_ComCANG3_HDL16TO" VALUE 0x80282C04 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_ComCANG3_HDL17TO_C "Behaviour control masks / Behaviour control masks of check DFC_ComCANG3_HDL17TO" VALUE 0x80282C06 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_ComCANG3_HDL18TO_C "Behaviour control masks / Behaviour control masks of check DFC_ComCANG3_HDL18TO" VALUE 0x80282C08 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_ComCANG3_HDL19TO_C "Behaviour control masks / Behaviour control masks of check DFC_ComCANG3_HDL19TO" VALUE 0x80282C0A Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_ComCANG3_HDL1TO_C "Behaviour control masks / Behaviour control masks of check DFC_ComCANG3_HDL1TO" VALUE 0x80282C0C Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_ComCANG3_HDL20TO_C "Behaviour control masks / Behaviour control masks of check DFC_ComCANG3_HDL20TO" VALUE 0x80282C0E Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_ComCANG3_HDL21TO_C "Behaviour control masks / Behaviour control masks of check DFC_ComCANG3_HDL21TO" VALUE 0x80282C10 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_ComCANG3_HDL22TO_C "Behaviour control masks / Behaviour control masks of check DFC_ComCANG3_HDL22TO" VALUE 0x80282C12 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_ComCANG3_HDL23TO_C "Behaviour control masks / Behaviour control masks of check DFC_ComCANG3_HDL23TO" VALUE 0x80282C14 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_ComCANG3_HDL24TO_C "Behaviour control masks / Behaviour control masks of check DFC_ComCANG3_HDL24TO" VALUE 0x80282C16 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_ComCANG3_HDL2TO_C "Behaviour control masks / Behaviour control masks of check DFC_ComCANG3_HDL2TO" VALUE 0x80282C18 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_ComCANG3_HDL3TO_C "Behaviour control masks / Behaviour control masks of check DFC_ComCANG3_HDL3TO" VALUE 0x80282C1A Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_ComCANG3_HDL4TO_C "Behaviour control masks / Behaviour control masks of check DFC_ComCANG3_HDL4TO" VALUE 0x80282C1C Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_ComCANG3_HDL5TO_C "Behaviour control masks / Behaviour control masks of check DFC_ComCANG3_HDL5TO" VALUE 0x80282C1E Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_ComCANG3_HDL6TO_C "Behaviour control masks / Behaviour control masks of check DFC_ComCANG3_HDL6TO" VALUE 0x80282C20 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_ComCANG3_HDL7TO_C "Behaviour control masks / Behaviour control masks of check DFC_ComCANG3_HDL7TO" VALUE 0x80282C22 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_ComCANG3_HDL8TO_C "Behaviour control masks / Behaviour control masks of check DFC_ComCANG3_HDL8TO" VALUE 0x80282C24 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_ComCANG3_HDL9TO_C "Behaviour control masks / Behaviour control masks of check DFC_ComCANG3_HDL9TO" VALUE 0x80282C26 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_ComCANG4_HDL0TO_C "Behaviour control masks / Behaviour control masks of check DFC_ComCANG4_HDL0TO" VALUE 0x80282C28 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_ComCANG4_HDL10TO_C "Behaviour control masks / Behaviour control masks of check DFC_ComCANG4_HDL10TO" VALUE 0x80282C2A Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_ComCANG4_HDL11TO_C "Behaviour control masks / Behaviour control masks of check DFC_ComCANG4_HDL11TO" VALUE 0x80282C2C Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_ComCANG4_HDL12TO_C "Behaviour control masks / Behaviour control masks of check DFC_ComCANG4_HDL12TO" VALUE 0x80282C2E Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_ComCANG4_HDL13TO_C "Behaviour control masks / Behaviour control masks of check DFC_ComCANG4_HDL13TO" VALUE 0x80282C30 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_ComCANG4_HDL14TO_C "Behaviour control masks / Behaviour control masks of check DFC_ComCANG4_HDL14TO" VALUE 0x80282C32 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_ComCANG4_HDL15TO_C "Behaviour control masks / Behaviour control masks of check DFC_ComCANG4_HDL15TO" VALUE 0x80282C34 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_ComCANG4_HDL16TO_C "Behaviour control masks / Behaviour control masks of check DFC_ComCANG4_HDL16TO" VALUE 0x80282C36 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_ComCANG4_HDL17TO_C "Behaviour control masks / Behaviour control masks of check DFC_ComCANG4_HDL17TO" VALUE 0x80282C38 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_ComCANG4_HDL18TO_C "Behaviour control masks / Behaviour control masks of check DFC_ComCANG4_HDL18TO" VALUE 0x80282C3A Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_ComCANG4_HDL19TO_C "Behaviour control masks / Behaviour control masks of check DFC_ComCANG4_HDL19TO" VALUE 0x80282C3C Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_ComCANG4_HDL1TO_C "Behaviour control masks / Behaviour control masks of check DFC_ComCANG4_HDL1TO" VALUE 0x80282C3E Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_ComCANG4_HDL20TO_C "Behaviour control masks / Behaviour control masks of check DFC_ComCANG4_HDL20TO" VALUE 0x80282C40 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_ComCANG4_HDL21TO_C "Behaviour control masks / Behaviour control masks of check DFC_ComCANG4_HDL21TO" VALUE 0x80282C42 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_ComCANG4_HDL22TO_C "Behaviour control masks / Behaviour control masks of check DFC_ComCANG4_HDL22TO" VALUE 0x80282C44 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_ComCANG4_HDL23TO_C "Behaviour control masks / Behaviour control masks of check DFC_ComCANG4_HDL23TO" VALUE 0x80282C46 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_ComCANG4_HDL24TO_C "Behaviour control masks / Behaviour control masks of check DFC_ComCANG4_HDL24TO" VALUE 0x80282C48 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_ComCANG4_HDL2TO_C "Behaviour control masks / Behaviour control masks of check DFC_ComCANG4_HDL2TO" VALUE 0x80282C4A Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_ComCANG4_HDL3TO_C "Behaviour control masks / Behaviour control masks of check DFC_ComCANG4_HDL3TO" VALUE 0x80282C4C Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_ComCANG4_HDL4TO_C "Behaviour control masks / Behaviour control masks of check DFC_ComCANG4_HDL4TO" VALUE 0x80282C4E Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_ComCANG4_HDL5TO_C "Behaviour control masks / Behaviour control masks of check DFC_ComCANG4_HDL5TO" VALUE 0x80282C50 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_ComCANG4_HDL6TO_C "Behaviour control masks / Behaviour control masks of check DFC_ComCANG4_HDL6TO" VALUE 0x80282C52 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_ComCANG4_HDL7TO_C "Behaviour control masks / Behaviour control masks of check DFC_ComCANG4_HDL7TO" VALUE 0x80282C54 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_ComCANG4_HDL8TO_C "Behaviour control masks / Behaviour control masks of check DFC_ComCANG4_HDL8TO" VALUE 0x80282C56 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_ComCANG4_HDL9TO_C "Behaviour control masks / Behaviour control masks of check DFC_ComCANG4_HDL9TO" VALUE 0x80282C58 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_Cy150SpiCom_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_Cy150SpiCom" VALUE 0x80282C5A Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_Cy320SpiCom_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_Cy320SpiCom" VALUE 0x80282C5C Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_MonUMaxSupply1_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_MonUMaxSupply1" VALUE 0x80282C5E Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_MonUMaxSupply2_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_MonUMaxSupply2" VALUE 0x80282C60 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_MonUMaxSupply3_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_MonUMaxSupply3" VALUE 0x80282C62 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_MonUMinSupply1_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_MonUMinSupply1" VALUE 0x80282C64 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_MonUMinSupply2_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_MonUMinSupply2" VALUE 0x80282C66 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_MonUMinSupply3_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_MonUMinSupply3" VALUE 0x80282C68 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_SSpMon1_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_SSpMon1" VALUE 0x80282C6A Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_SSpMon1OV_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_SSpMon1OV" VALUE 0x80282C6C Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_SSpMon1UV_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_SSpMon1UV" VALUE 0x80282C6E Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_SSpMon2_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_SSpMon2" VALUE 0x80282C70 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_SSpMon2OV_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_SSpMon2OV" VALUE 0x80282C72 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_SSpMon2UV_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_SSpMon2UV" VALUE 0x80282C74 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_SSpMon3_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_SSpMon3" VALUE 0x80282C76 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_SSpMon3OV_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_SSpMon3OV" VALUE 0x80282C78 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_SSpMon3UV_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_SSpMon3UV" VALUE 0x80282C7A Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_HDEVK_MIN_0_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_HDEVK_MIN_0" VALUE 0x80282C7C Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_HDEVK_MIN_1_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_HDEVK_MIN_1" VALUE 0x80282C7E Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_HDEVK_NPL_0_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_HDEVK_NPL_0" VALUE 0x80282C80 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_HDEVK_NPL_1_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_HDEVK_NPL_1" VALUE 0x80282C82 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_HDEVK_SIG_0_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_HDEVK_SIG_0" VALUE 0x80282C84 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_HDEVK_SIG_1_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_HDEVK_SIG_1" VALUE 0x80282C86 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_IgnClPsClOpen0_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_IgnClPsClOpen0" VALUE 0x80282C88 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_IgnClPsClOpen1_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_IgnClPsClOpen1" VALUE 0x80282C8A Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_IgnClPsClOpen2_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_IgnClPsClOpen2" VALUE 0x80282C8C Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_IgnClPsClOpen3_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_IgnClPsClOpen3" VALUE 0x80282C8E Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_IgnClPsClOpen4_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_IgnClPsClOpen4" VALUE 0x80282C90 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_IgnClPsClOpen5_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_IgnClPsClOpen5" VALUE 0x80282C92 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_IgnClPsClOpen6_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_IgnClPsClOpen6" VALUE 0x80282C94 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_IgnClPsClOpen7_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_IgnClPsClOpen7" VALUE 0x80282C96 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_IgnClPsClShCir0_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_IgnClPsClShCir0" VALUE 0x80282C98 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_IgnClPsClShCir1_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_IgnClPsClShCir1" VALUE 0x80282C9A Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_IgnClPsClShCir2_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_IgnClPsClShCir2" VALUE 0x80282C9C Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_IgnClPsClShCir3_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_IgnClPsClShCir3" VALUE 0x80282C9E Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_IgnClPsClShCir4_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_IgnClPsClShCir4" VALUE 0x80282CA0 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_IgnClPsClShCir5_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_IgnClPsClShCir5" VALUE 0x80282CA2 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_IgnClPsClShCir6_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_IgnClPsClShCir6" VALUE 0x80282CA4 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_IgnClPsClShCir7_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_IgnClPsClShCir7" VALUE 0x80282CA6 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_IgnClPsClUnExpt0_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_IgnClPsClUnExpt0" VALUE 0x80282CA8 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_IgnClPsClUnExpt1_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_IgnClPsClUnExpt1" VALUE 0x80282CAA Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_IgnClPsClUnExpt2_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_IgnClPsClUnExpt2" VALUE 0x80282CAC Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_IgnClPsClUnExpt3_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_IgnClPsClUnExpt3" VALUE 0x80282CAE Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_IgnClPsClUnExpt4_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_IgnClPsClUnExpt4" VALUE 0x80282CB0 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_IgnClPsClUnExpt5_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_IgnClPsClUnExpt5" VALUE 0x80282CB2 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_IgnClPsClUnExpt6_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_IgnClPsClUnExpt6" VALUE 0x80282CB4 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_IgnClPsClUnExpt7_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_IgnClPsClUnExpt7" VALUE 0x80282CB6 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_IgnClPsDevIdentErr1_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_IgnClPsDevIdentErr1" VALUE 0x80282CB8 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_IgnClPsDevIdentErr2_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_IgnClPsDevIdentErr2" VALUE 0x80282CBA Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_IgnClPsDevInitErr1_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_IgnClPsDevInitErr1" VALUE 0x80282CBC Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_IgnClPsDevInitErr2_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_IgnClPsDevInitErr2" VALUE 0x80282CBE Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_IgnClPsDevOscErr1_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_IgnClPsDevOscErr1" VALUE 0x80282CC0 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_IgnClPsDevOscErr2_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_IgnClPsDevOscErr2" VALUE 0x80282CC2 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_IgnClPsDevSpiErr1_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_IgnClPsDevSpiErr1" VALUE 0x80282CC4 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_IgnClPsDevSpiErr2_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_IgnClPsDevSpiErr2" VALUE 0x80282CC6 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_IgnClPsOpenLoad0_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_IgnClPsOpenLoad0" VALUE 0x80282CC8 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_IgnClPsOpenLoad1_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_IgnClPsOpenLoad1" VALUE 0x80282CCA Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_IgnClPsOpenLoad2_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_IgnClPsOpenLoad2" VALUE 0x80282CCC Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_IgnClPsOpenLoad3_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_IgnClPsOpenLoad3" VALUE 0x80282CCE Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_IgnClPsOpenLoad4_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_IgnClPsOpenLoad4" VALUE 0x80282CD0 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_IgnClPsOpenLoad5_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_IgnClPsOpenLoad5" VALUE 0x80282CD2 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_IgnClPsOpenLoad6_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_IgnClPsOpenLoad6" VALUE 0x80282CD4 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_IgnClPsOpenLoad7_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_IgnClPsOpenLoad7" VALUE 0x80282CD6 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_IgnClPsShCirBatt0_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_IgnClPsShCirBatt0" VALUE 0x80282CD8 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_IgnClPsShCirBatt1_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_IgnClPsShCirBatt1" VALUE 0x80282CDA Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_IgnClPsShCirBatt2_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_IgnClPsShCirBatt2" VALUE 0x80282CDC Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_IgnClPsShCirBatt3_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_IgnClPsShCirBatt3" VALUE 0x80282CDE Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_IgnClPsShCirBatt4_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_IgnClPsShCirBatt4" VALUE 0x80282CE0 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_IgnClPsShCirBatt5_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_IgnClPsShCirBatt5" VALUE 0x80282CE2 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_IgnClPsShCirBatt6_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_IgnClPsShCirBatt6" VALUE 0x80282CE4 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_IgnClPsShCirBatt7_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_IgnClPsShCirBatt7" VALUE 0x80282CE6 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_IgnClPsShCirGnd0_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_IgnClPsShCirGnd0" VALUE 0x80282CE8 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_IgnClPsShCirGnd1_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_IgnClPsShCirGnd1" VALUE 0x80282CEA Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_IgnClPsShCirGnd2_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_IgnClPsShCirGnd2" VALUE 0x80282CEC Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_IgnClPsShCirGnd3_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_IgnClPsShCirGnd3" VALUE 0x80282CEE Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_IgnClPsShCirGnd4_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_IgnClPsShCirGnd4" VALUE 0x80282CF0 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_IgnClPsShCirGnd5_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_IgnClPsShCirGnd5" VALUE 0x80282CF2 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_IgnClPsShCirGnd6_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_IgnClPsShCirGnd6" VALUE 0x80282CF4 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_IgnClPsShCirGnd7_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_IgnClPsShCirGnd7" VALUE 0x80282CF6 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_KnDetSens1PortAMax_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_KnDetSens1PortAMax" VALUE 0x80282CF8 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_KnDetSens1PortAMin_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_KnDetSens1PortAMin" VALUE 0x80282CFA Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_KnDetSens1PortBMax_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_KnDetSens1PortBMax" VALUE 0x80282CFC Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_KnDetSens1PortBMin_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_KnDetSens1PortBMin" VALUE 0x80282CFE Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_KnDetSens2PortAMax_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_KnDetSens2PortAMax" VALUE 0x80282D00 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_KnDetSens2PortAMin_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_KnDetSens2PortAMin" VALUE 0x80282D02 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_KnDetSens2PortBMax_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_KnDetSens2PortBMax" VALUE 0x80282D04 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_KnDetSens2PortBMin_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_KnDetSens2PortBMin" VALUE 0x80282D06 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_KnDetSens3PortAMax_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_KnDetSens3PortAMax" VALUE 0x80282D08 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_KnDetSens3PortAMin_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_KnDetSens3PortAMin" VALUE 0x80282D0A Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_KnDetSens3PortBMax_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_KnDetSens3PortBMax" VALUE 0x80282D0C Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_KnDetSens3PortBMin_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_KnDetSens3PortBMin" VALUE 0x80282D0E Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_KnDetSens4PortAMax_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_KnDetSens4PortAMax" VALUE 0x80282D10 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_KnDetSens4PortAMin_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_KnDetSens4PortAMin" VALUE 0x80282D12 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_KnDetSens4PortBMax_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_KnDetSens4PortBMax" VALUE 0x80282D14 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_KnDetSens4PortBMin_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_KnDetSens4PortBMin" VALUE 0x80282D16 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_MfPsNonPlausible_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_MfPsNonPlausible" VALUE 0x80282D18 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_MfPsNonPlausible2_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_MfPsNonPlausible2" VALUE 0x80282D1A Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_MfPsOpenLoad_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_MfPsOpenLoad" VALUE 0x80282D1C Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_MfPsOpenLoad2_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_MfPsOpenLoad2" VALUE 0x80282D1E Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_MfPsShCirBattLowSide_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_MfPsShCirBattLowSide" VALUE 0x80282D20 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_MfPsShCirBattLowSide2_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_MfPsShCirBattLowSide2" VALUE 0x80282D22 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_MfPsShCirGndLowSide_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_MfPsShCirGndLowSide" VALUE 0x80282D24 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_MfPsShCirGndLowSide2_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_MfPsShCirGndLowSide2" VALUE 0x80282D26 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_DevLibBattUHi_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_DevLibBattUHi" VALUE 0x80282D28 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_DevLibBattULo_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_DevLibBattULo" VALUE 0x80282D2A Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_DSMDummy_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_DSMDummy" VALUE 0x80282D2C Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_EEPEraseErr_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_EEPEraseErr" VALUE 0x80282D2E Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_EEPRdErr_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_EEPRdErr" VALUE 0x80282D30 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_EEPWrErr_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_EEPWrErr" VALUE 0x80282D32 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_EV1max_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_EV1max" VALUE 0x80282D34 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_EV1min_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_EV1min" VALUE 0x80282D36 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_EV1sig_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_EV1sig" VALUE 0x80282D38 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_EV2max_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_EV2max" VALUE 0x80282D3A Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_EV2min_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_EV2min" VALUE 0x80282D3C Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_EV2sig_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_EV2sig" VALUE 0x80282D3E Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_EV3max_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_EV3max" VALUE 0x80282D40 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_EV3min_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_EV3min" VALUE 0x80282D42 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_EV3sig_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_EV3sig" VALUE 0x80282D44 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_EV4max_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_EV4max" VALUE 0x80282D46 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_EV4min_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_EV4min" VALUE 0x80282D48 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_EV4sig_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_EV4sig" VALUE 0x80282D4A Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_EV5max_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_EV5max" VALUE 0x80282D4C Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_EV5min_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_EV5min" VALUE 0x80282D4E Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_EV5sig_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_EV5sig" VALUE 0x80282D50 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_EV6max_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_EV6max" VALUE 0x80282D52 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_EV6min_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_EV6min" VALUE 0x80282D54 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_EV6sig_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_EV6sig" VALUE 0x80282D56 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_EV7max_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_EV7max" VALUE 0x80282D58 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_EV7min_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_EV7min" VALUE 0x80282D5A Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_EV7sig_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_EV7sig" VALUE 0x80282D5C Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_EV8max_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_EV8max" VALUE 0x80282D5E Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_EV8min_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_EV8min" VALUE 0x80282D60 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_EV8sig_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_EV8sig" VALUE 0x80282D62 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_EpmCaSI1ErrSig_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_EpmCaSI1ErrSig" VALUE 0x80282D64 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_EpmCaSI1NoSigMax_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_EpmCaSI1NoSigMax" VALUE 0x80282D66 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_EpmCaSI1NoSigMin_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_EpmCaSI1NoSigMin" VALUE 0x80282D68 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_EpmCaSI1OfsErr_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_EpmCaSI1OfsErr" VALUE 0x80282D6A Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_EpmCaSI2ErrSig_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_EpmCaSI2ErrSig" VALUE 0x80282D6C Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_EpmCaSI2NoSigMax_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_EpmCaSI2NoSigMax" VALUE 0x80282D6E Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_EpmCaSI2NoSigMin_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_EpmCaSI2NoSigMin" VALUE 0x80282D70 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_EpmCaSI2OfsErr_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_EpmCaSI2OfsErr" VALUE 0x80282D72 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_EpmCaSO1ErrSig_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_EpmCaSO1ErrSig" VALUE 0x80282D74 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_EpmCaSO1NoSigMax_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_EpmCaSO1NoSigMax" VALUE 0x80282D76 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_EpmCaSO1NoSigMin_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_EpmCaSO1NoSigMin" VALUE 0x80282D78 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_EpmCaSO1OfsErr_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_EpmCaSO1OfsErr" VALUE 0x80282D7A Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_EpmCaSO2ErrSig_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_EpmCaSO2ErrSig" VALUE 0x80282D7C Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_EpmCaSO2NoSigMax_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_EpmCaSO2NoSigMax" VALUE 0x80282D7E Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_EpmCaSO2NoSigMin_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_EpmCaSO2NoSigMin" VALUE 0x80282D80 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_EpmCaSO2OfsErr_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_EpmCaSO2OfsErr" VALUE 0x80282D82 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_EpmCrSDGI_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_EpmCrSDGI" VALUE 0x80282D84 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_EpmCrSErrSig_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_EpmCrSErrSig" VALUE 0x80282D86 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_EpmCrSNoSig_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_EpmCrSNoSig" VALUE 0x80282D88 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_HDEVH_MAX_0_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_HDEVH_MAX_0" VALUE 0x80282D8A Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_HDEVH_MAX_1_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_HDEVH_MAX_1" VALUE 0x80282D8C Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_HDEVH_MAX_2_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_HDEVH_MAX_2" VALUE 0x80282D8E Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_HDEVH_MAX_3_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_HDEVH_MAX_3" VALUE 0x80282D90 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_HDEVH_MAX_4_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_HDEVH_MAX_4" VALUE 0x80282D92 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_HDEVH_MAX_5_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_HDEVH_MAX_5" VALUE 0x80282D94 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_HDEVH_MAX_6_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_HDEVH_MAX_6" VALUE 0x80282D96 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_HDEVH_MAX_7_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_HDEVH_MAX_7" VALUE 0x80282D98 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_HDEVH_MIN_0_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_HDEVH_MIN_0" VALUE 0x80282D9A Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_HDEVH_MIN_1_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_HDEVH_MIN_1" VALUE 0x80282D9C Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_HDEVH_MIN_2_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_HDEVH_MIN_2" VALUE 0x80282D9E Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_HDEVH_MIN_3_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_HDEVH_MIN_3" VALUE 0x80282DA0 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_HDEVH_MIN_4_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_HDEVH_MIN_4" VALUE 0x80282DA2 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_HDEVH_MIN_5_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_HDEVH_MIN_5" VALUE 0x80282DA4 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_HDEVH_MIN_6_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_HDEVH_MIN_6" VALUE 0x80282DA6 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_HDEVH_MIN_7_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_HDEVH_MIN_7" VALUE 0x80282DA8 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_HDEVH_NPL_0_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_HDEVH_NPL_0" VALUE 0x80282DAA Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_HDEVH_NPL_1_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_HDEVH_NPL_1" VALUE 0x80282DAC Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_HDEVH_NPL_2_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_HDEVH_NPL_2" VALUE 0x80282DAE Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_HDEVH_NPL_3_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_HDEVH_NPL_3" VALUE 0x80282DB0 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_HDEVH_NPL_4_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_HDEVH_NPL_4" VALUE 0x80282DB2 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_HDEVH_NPL_5_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_HDEVH_NPL_5" VALUE 0x80282DB4 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_HDEVH_NPL_6_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_HDEVH_NPL_6" VALUE 0x80282DB6 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_HDEVH_NPL_7_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_HDEVH_NPL_7" VALUE 0x80282DB8 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_HDEVL_MAX_0_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_HDEVL_MAX_0" VALUE 0x80282DBA Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_HDEVL_MAX_1_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_HDEVL_MAX_1" VALUE 0x80282DBC Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_HDEVL_MAX_2_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_HDEVL_MAX_2" VALUE 0x80282DBE Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_HDEVL_MAX_3_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_HDEVL_MAX_3" VALUE 0x80282DC0 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_HDEVL_MAX_4_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_HDEVL_MAX_4" VALUE 0x80282DC2 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_HDEVL_MAX_5_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_HDEVL_MAX_5" VALUE 0x80282DC4 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_HDEVL_MAX_6_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_HDEVL_MAX_6" VALUE 0x80282DC6 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_HDEVL_MAX_7_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_HDEVL_MAX_7" VALUE 0x80282DC8 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_HDEVL_MIN_0_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_HDEVL_MIN_0" VALUE 0x80282DCA Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_HDEVL_MIN_1_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_HDEVL_MIN_1" VALUE 0x80282DCC Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_HDEVL_MIN_2_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_HDEVL_MIN_2" VALUE 0x80282DCE Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_HDEVL_MIN_3_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_HDEVL_MIN_3" VALUE 0x80282DD0 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_HDEVL_MIN_4_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_HDEVL_MIN_4" VALUE 0x80282DD2 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_HDEVL_MIN_5_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_HDEVL_MIN_5" VALUE 0x80282DD4 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_HDEVL_MIN_6_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_HDEVL_MIN_6" VALUE 0x80282DD6 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_HDEVL_MIN_7_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_HDEVL_MIN_7" VALUE 0x80282DD8 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_HDEVL_NPL_0_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_HDEVL_NPL_0" VALUE 0x80282DDA Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_HDEVL_NPL_1_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_HDEVL_NPL_1" VALUE 0x80282DDC Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_HDEVL_NPL_2_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_HDEVL_NPL_2" VALUE 0x80282DDE Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_HDEVL_NPL_3_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_HDEVL_NPL_3" VALUE 0x80282DE0 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_HDEVL_NPL_4_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_HDEVL_NPL_4" VALUE 0x80282DE2 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_HDEVL_NPL_5_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_HDEVL_NPL_5" VALUE 0x80282DE4 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_HDEVL_NPL_6_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_HDEVL_NPL_6" VALUE 0x80282DE6 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_HDEVL_NPL_7_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_HDEVL_NPL_7" VALUE 0x80282DE8 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_HDEVL_SIG_0_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_HDEVL_SIG_0" VALUE 0x80282DEA Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_HDEVL_SIG_1_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_HDEVL_SIG_1" VALUE 0x80282DEC Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_HDEVL_SIG_2_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_HDEVL_SIG_2" VALUE 0x80282DEE Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_HDEVL_SIG_3_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_HDEVL_SIG_3" VALUE 0x80282DF0 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_HDEVL_SIG_4_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_HDEVL_SIG_4" VALUE 0x80282DF2 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_HDEVL_SIG_5_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_HDEVL_SIG_5" VALUE 0x80282DF4 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_HDEVL_SIG_6_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_HDEVL_SIG_6" VALUE 0x80282DF6 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_HDEVL_SIG_7_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_HDEVL_SIG_7" VALUE 0x80282DF8 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_HSFE2max_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_HSFE2max" VALUE 0x80282DFA Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_HSFE2min_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_HSFE2min" VALUE 0x80282DFC Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_HSFE2sig_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_HSFE2sig" VALUE 0x80282DFE Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_HSFEmax_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_HSFEmax" VALUE 0x80282E00 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_HSFEmin_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_HSFEmin" VALUE 0x80282E02 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_HSFEsig_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_HSFEsig" VALUE 0x80282E04 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_HSHE2max_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_HSHE2max" VALUE 0x80282E06 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_HSHE2min_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_HSHE2min" VALUE 0x80282E08 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_HSHE2sig_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_HSHE2sig" VALUE 0x80282E0A Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_HSHEmax_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_HSHEmax" VALUE 0x80282E0C Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_HSHEmin_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_HSHEmin" VALUE 0x80282E0E Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_HSHEsig_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_HSHEsig" VALUE 0x80282E10 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_HSVE2max_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_HSVE2max" VALUE 0x80282E12 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_HSVE2maxLSF_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_HSVE2maxLSF" VALUE 0x80282E14 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_HSVE2min_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_HSVE2min" VALUE 0x80282E16 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_HSVE2minLSF_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_HSVE2minLSF" VALUE 0x80282E18 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_HSVE2sig_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_HSVE2sig" VALUE 0x80282E1A Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_HSVE2sigLSF_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_HSVE2sigLSF" VALUE 0x80282E1C Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_HSVEmax_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_HSVEmax" VALUE 0x80282E1E Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_HSVEmaxLSF_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_HSVEmaxLSF" VALUE 0x80282E20 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_HSVEmin_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_HSVEmin" VALUE 0x80282E22 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_HSVEminLSF_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_HSVEminLSF" VALUE 0x80282E24 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_HSVEsig_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_HSVEsig" VALUE 0x80282E26 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_HSVEsigLSF_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_HSVEsigLSF" VALUE 0x80282E28 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_ICLSU2max_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_ICLSU2max" VALUE 0x80282E2A Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_ICLSU2min_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_ICLSU2min" VALUE 0x80282E2C Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_ICLSU2npl_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_ICLSU2npl" VALUE 0x80282E2E Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_ICLSU2sig_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_ICLSU2sig" VALUE 0x80282E30 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_ICLSUmax_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_ICLSUmax" VALUE 0x80282E32 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_ICLSUmin_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_ICLSUmin" VALUE 0x80282E34 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_ICLSUnpl_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_ICLSUnpl" VALUE 0x80282E36 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_ICLSUsig_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_ICLSUsig" VALUE 0x80282E38 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_LSF2max_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_LSF2max" VALUE 0x80282E3A Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_LSF2min_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_LSF2min" VALUE 0x80282E3C Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_LSF2npl_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_LSF2npl" VALUE 0x80282E3E Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_LSF2sig_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_LSF2sig" VALUE 0x80282E40 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_LSFmax_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_LSFmax" VALUE 0x80282E42 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_LSFmin_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_LSFmin" VALUE 0x80282E44 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_LSFnpl_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_LSFnpl" VALUE 0x80282E46 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_LSFsig_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_LSFsig" VALUE 0x80282E48 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_LSH2max_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_LSH2max" VALUE 0x80282E4A Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_LSH2min_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_LSH2min" VALUE 0x80282E4C Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_LSH2npl_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_LSH2npl" VALUE 0x80282E4E Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_LSH2sig_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_LSH2sig" VALUE 0x80282E50 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_LSHmax_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_LSHmax" VALUE 0x80282E52 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_LSHmin_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_LSHmin" VALUE 0x80282E54 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_LSHnpl_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_LSHnpl" VALUE 0x80282E56 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_LSHsig_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_LSHsig" VALUE 0x80282E58 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_LSUIA2sig_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_LSUIA2sig" VALUE 0x80282E5A Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_LSUIAsig_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_LSUIAsig" VALUE 0x80282E5C Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_LSUIP2max_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_LSUIP2max" VALUE 0x80282E5E Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_LSUIP2npl_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_LSUIP2npl" VALUE 0x80282E60 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_LSUIP2sig_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_LSUIP2sig" VALUE 0x80282E62 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_LSUIPmax_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_LSUIPmax" VALUE 0x80282E64 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_LSUIPnpl_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_LSUIPnpl" VALUE 0x80282E66 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_LSUIPsig_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_LSUIPsig" VALUE 0x80282E68 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_LSUKS2max_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_LSUKS2max" VALUE 0x80282E6A Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_LSUKS2min_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_LSUKS2min" VALUE 0x80282E6C Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_LSUKSmax_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_LSUKSmax" VALUE 0x80282E6E Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_LSUKSmin_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_LSUKSmin" VALUE 0x80282E70 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_LSUUN2sig_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_LSUUN2sig" VALUE 0x80282E72 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_LSUUNsig_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_LSUUNsig" VALUE 0x80282E74 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_LSUVM2sig_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_LSUVM2sig" VALUE 0x80282E76 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_LSUVMsig_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_LSUVMsig" VALUE 0x80282E78 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_LSV2max_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_LSV2max" VALUE 0x80282E7A Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_LSV2min_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_LSV2min" VALUE 0x80282E7C Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_LSV2npl_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_LSV2npl" VALUE 0x80282E7E Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_LSV2sig_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_LSV2sig" VALUE 0x80282E80 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_LSVmax_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_LSVmax" VALUE 0x80282E82 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_LSVmin_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_LSVmin" VALUE 0x80282E84 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_LSVnpl_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_LSVnpl" VALUE 0x80282E86 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_LSVsig_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_LSVsig" VALUE 0x80282E88 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_MD00max_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_MD00max" VALUE 0x80282E8A Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_MD00min_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_MD00min" VALUE 0x80282E8C Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_MD00npl_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_MD00npl" VALUE 0x80282E8E Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_MD01max_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_MD01max" VALUE 0x80282E90 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_MD01min_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_MD01min" VALUE 0x80282E92 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_MD01npl_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_MD01npl" VALUE 0x80282E94 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_MD02max_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_MD02max" VALUE 0x80282E96 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_MD02min_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_MD02min" VALUE 0x80282E98 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_MD02npl_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_MD02npl" VALUE 0x80282E9A Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_MD03max_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_MD03max" VALUE 0x80282E9C Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_MD03min_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_MD03min" VALUE 0x80282E9E Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_MD03npl_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_MD03npl" VALUE 0x80282EA0 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_MD04max_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_MD04max" VALUE 0x80282EA2 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_MD04min_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_MD04min" VALUE 0x80282EA4 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_MD04npl_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_MD04npl" VALUE 0x80282EA6 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_MD05max_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_MD05max" VALUE 0x80282EA8 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_MD05min_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_MD05min" VALUE 0x80282EAA Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_MD05npl_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_MD05npl" VALUE 0x80282EAC Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_MD06max_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_MD06max" VALUE 0x80282EAE Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_MD06min_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_MD06min" VALUE 0x80282EB0 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_MD06npl_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_MD06npl" VALUE 0x80282EB2 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_MD07max_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_MD07max" VALUE 0x80282EB4 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_MD07min_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_MD07min" VALUE 0x80282EB6 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_MD07npl_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_MD07npl" VALUE 0x80282EB8 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_MDmax_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_MDmax" VALUE 0x80282EBA Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_MDmin_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_MDmin" VALUE 0x80282EBC Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_MDnpl_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_MDnpl" VALUE 0x80282EBE Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_MRlyErlyOpng_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_MRlyErlyOpng" VALUE 0x80282EC0 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_MRlyStk_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_MRlyStk" VALUE 0x80282EC2 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_PLLSUmax_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_PLLSUmax" VALUE 0x80282EC4 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_PLLSUmin_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_PLLSUmin" VALUE 0x80282EC6 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_PLLSUnpl_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_PLLSUnpl" VALUE 0x80282EC8 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_PLLSUsig_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_PLLSUsig" VALUE 0x80282ECA Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_SWReset_0_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_SWReset_0" VALUE 0x80282ECC Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_SWReset_1_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_SWReset_1" VALUE 0x80282ECE Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_CtlMsk.DFC_SWReset_2_C "Behaviour control masks / extended customer specific diagnostic trouble code for check DFC_SWReset_2" VALUE 0x80282ED0 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_DisblMsk.DFC_Unused_C "DFC / " VALUE 0x802836F2 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" READ_ONLY /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_DisblMsk.DFC_BusDiagBusOffErrPasNodeA_C "DFC / Disable masks of check DFC_BusDiagBusOffErrPasNodeA" VALUE 0x802836F4 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_DisblMsk.DFC_BusDiagBusOffErrPasNodeB_C "DFC / Disable masks of check DFC_BusDiagBusOffErrPasNodeB" VALUE 0x802836F6 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_DisblMsk.DFC_BusDiagBusOffErrPasNodeC_C "DFC / Disable masks of check DFC_BusDiagBusOffErrPasNodeC" VALUE 0x802836F8 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_DisblMsk.DFC_BusDiagBusOffErrPasNodeD_C "DFC / Disable masks of check DFC_BusDiagBusOffErrPasNodeD" VALUE 0x802836FA Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_DisblMsk.DFC_BusDiagBusOffNodeA_C "DFC / Disable masks of check DFC_BusDiagBusOffNodeA" VALUE 0x802836FC Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_DisblMsk.DFC_BusDiagBusOffNodeB_C "DFC / Disable masks of check DFC_BusDiagBusOffNodeB" VALUE 0x802836FE Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_DisblMsk.DFC_BusDiagBusOffNodeC_C "DFC / Disable masks of check DFC_BusDiagBusOffNodeC" VALUE 0x80283700 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_DisblMsk.DFC_BusDiagBusOffNodeD_C "DFC / Disable masks of check DFC_BusDiagBusOffNodeD" VALUE 0x80283702 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_DisblMsk.DFC_ComCANG1_HDL0TO_C "DFC / Disable masks of check DFC_ComCANG1_HDL0TO" VALUE 0x80283704 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_DisblMsk.DFC_ComCANG1_HDL10TO_C "DFC / Disable masks of check DFC_ComCANG1_HDL10TO" VALUE 0x80283706 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_DisblMsk.DFC_ComCANG1_HDL11TO_C "DFC / Disable masks of check DFC_ComCANG1_HDL11TO" VALUE 0x80283708 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_DisblMsk.DFC_ComCANG1_HDL12TO_C "DFC / Disable masks of check DFC_ComCANG1_HDL12TO" VALUE 0x8028370A Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_DisblMsk.DFC_ComCANG1_HDL13TO_C "DFC / Disable masks of check DFC_ComCANG1_HDL13TO" VALUE 0x8028370C Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_DisblMsk.DFC_ComCANG1_HDL14TO_C "DFC / Disable masks of check DFC_ComCANG1_HDL14TO" VALUE 0x8028370E Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_DisblMsk.DFC_ComCANG1_HDL15TO_C "DFC / Disable masks of check DFC_ComCANG1_HDL15TO" VALUE 0x80283710 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_DisblMsk.DFC_ComCANG1_HDL16TO_C "DFC / Disable masks of check DFC_ComCANG1_HDL16TO" VALUE 0x80283712 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_DisblMsk.DFC_ComCANG1_HDL17TO_C "DFC / Disable masks of check DFC_ComCANG1_HDL17TO" VALUE 0x80283714 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_DisblMsk.DFC_ComCANG1_HDL18TO_C "DFC / Disable masks of check DFC_ComCANG1_HDL18TO" VALUE 0x80283716 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_DisblMsk.DFC_ComCANG1_HDL19TO_C "DFC / Disable masks of check DFC_ComCANG1_HDL19TO" VALUE 0x80283718 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_DisblMsk.DFC_ComCANG1_HDL1TO_C "DFC / Disable masks of check DFC_ComCANG1_HDL1TO" VALUE 0x8028371A Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_DisblMsk.DFC_ComCANG1_HDL20TO_C "DFC / Disable masks of check DFC_ComCANG1_HDL20TO" VALUE 0x8028371C Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_DisblMsk.DFC_ComCANG1_HDL21TO_C "DFC / Disable masks of check DFC_ComCANG1_HDL21TO" VALUE 0x8028371E Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_DisblMsk.DFC_ComCANG1_HDL22TO_C "DFC / Disable masks of check DFC_ComCANG1_HDL22TO" VALUE 0x80283720 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_DisblMsk.DFC_ComCANG1_HDL23TO_C "DFC / Disable masks of check DFC_ComCANG1_HDL23TO" VALUE 0x80283722 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_DisblMsk.DFC_ComCANG1_HDL24TO_C "DFC / Disable masks of check DFC_ComCANG1_HDL24TO" VALUE 0x80283724 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_DisblMsk.DFC_ComCANG1_HDL2TO_C "DFC / Disable masks of check DFC_ComCANG1_HDL2TO" VALUE 0x80283726 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_DisblMsk.DFC_ComCANG1_HDL3TO_C "DFC / Disable masks of check DFC_ComCANG1_HDL3TO" VALUE 0x80283728 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_DisblMsk.DFC_ComCANG1_HDL4TO_C "DFC / Disable masks of check DFC_ComCANG1_HDL4TO" VALUE 0x8028372A Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_DisblMsk.DFC_ComCANG1_HDL5TO_C "DFC / Disable masks of check DFC_ComCANG1_HDL5TO" VALUE 0x8028372C Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_DisblMsk.DFC_ComCANG1_HDL6TO_C "DFC / Disable masks of check DFC_ComCANG1_HDL6TO" VALUE 0x8028372E Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_DisblMsk.DFC_ComCANG1_HDL7TO_C "DFC / Disable masks of check DFC_ComCANG1_HDL7TO" VALUE 0x80283730 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_DisblMsk.DFC_ComCANG1_HDL8TO_C "DFC / Disable masks of check DFC_ComCANG1_HDL8TO" VALUE 0x80283732 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_DisblMsk.DFC_ComCANG1_HDL9TO_C "DFC / Disable masks of check DFC_ComCANG1_HDL9TO" VALUE 0x80283734 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_DisblMsk.DFC_ComCANG2_HDL0TO_C "DFC / Disable masks of check DFC_ComCANG2_HDL0TO" VALUE 0x80283736 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_DisblMsk.DFC_ComCANG2_HDL10TO_C "DFC / Disable masks of check DFC_ComCANG2_HDL10TO" VALUE 0x80283738 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_DisblMsk.DFC_ComCANG2_HDL11TO_C "DFC / Disable masks of check DFC_ComCANG2_HDL11TO" VALUE 0x8028373A Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_DisblMsk.DFC_ComCANG2_HDL12TO_C "DFC / Disable masks of check DFC_ComCANG2_HDL12TO" VALUE 0x8028373C Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_DisblMsk.DFC_ComCANG2_HDL13TO_C "DFC / Disable masks of check DFC_ComCANG2_HDL13TO" VALUE 0x8028373E Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_DisblMsk.DFC_ComCANG2_HDL14TO_C "DFC / Disable masks of check DFC_ComCANG2_HDL14TO" VALUE 0x80283740 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_DisblMsk.DFC_ComCANG2_HDL15TO_C "DFC / Disable masks of check DFC_ComCANG2_HDL15TO" VALUE 0x80283742 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_DisblMsk.DFC_ComCANG2_HDL16TO_C "DFC / Disable masks of check DFC_ComCANG2_HDL16TO" VALUE 0x80283744 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_DisblMsk.DFC_ComCANG2_HDL17TO_C "DFC / Disable masks of check DFC_ComCANG2_HDL17TO" VALUE 0x80283746 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_DisblMsk.DFC_ComCANG2_HDL18TO_C "DFC / Disable masks of check DFC_ComCANG2_HDL18TO" VALUE 0x80283748 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_DisblMsk.DFC_ComCANG2_HDL19TO_C "DFC / Disable masks of check DFC_ComCANG2_HDL19TO" VALUE 0x8028374A Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_DisblMsk.DFC_ComCANG2_HDL1TO_C "DFC / Disable masks of check DFC_ComCANG2_HDL1TO" VALUE 0x8028374C Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_DisblMsk.DFC_ComCANG2_HDL20TO_C "DFC / Disable masks of check DFC_ComCANG2_HDL20TO" VALUE 0x8028374E Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_DisblMsk.DFC_ComCANG2_HDL21TO_C "DFC / Disable masks of check DFC_ComCANG2_HDL21TO" VALUE 0x80283750 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_DisblMsk.DFC_ComCANG2_HDL22TO_C "DFC / Disable masks of check DFC_ComCANG2_HDL22TO" VALUE 0x80283752 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_DisblMsk.DFC_ComCANG2_HDL23TO_C "DFC / Disable masks of check DFC_ComCANG2_HDL23TO" VALUE 0x80283754 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_DisblMsk.DFC_ComCANG2_HDL24TO_C "DFC / Disable masks of check DFC_ComCANG2_HDL24TO" VALUE 0x80283756 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_DisblMsk.DFC_ComCANG2_HDL2TO_C "DFC / Disable masks of check DFC_ComCANG2_HDL2TO" VALUE 0x80283758 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_DisblMsk.DFC_ComCANG2_HDL3TO_C "DFC / Disable masks of check DFC_ComCANG2_HDL3TO" VALUE 0x8028375A Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_DisblMsk.DFC_ComCANG2_HDL4TO_C "DFC / Disable masks of check DFC_ComCANG2_HDL4TO" VALUE 0x8028375C Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_DisblMsk.DFC_ComCANG2_HDL5TO_C "DFC / Disable masks of check DFC_ComCANG2_HDL5TO" VALUE 0x8028375E Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_DisblMsk.DFC_ComCANG2_HDL6TO_C "DFC / Disable masks of check DFC_ComCANG2_HDL6TO" VALUE 0x80283760 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_DisblMsk.DFC_ComCANG2_HDL7TO_C "DFC / Disable masks of check DFC_ComCANG2_HDL7TO" VALUE 0x80283762 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_DisblMsk.DFC_ComCANG2_HDL8TO_C "DFC / Disable masks of check DFC_ComCANG2_HDL8TO" VALUE 0x80283764 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_DisblMsk.DFC_ComCANG2_HDL9TO_C "DFC / Disable masks of check DFC_ComCANG2_HDL9TO" VALUE 0x80283766 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_DisblMsk.DFC_ComCANG3_HDL0TO_C "DFC / Disable masks of check DFC_ComCANG3_HDL0TO" VALUE 0x80283768 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_DisblMsk.DFC_ComCANG3_HDL10TO_C "DFC / Disable masks of check DFC_ComCANG3_HDL10TO" VALUE 0x8028376A Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_DisblMsk.DFC_ComCANG3_HDL11TO_C "DFC / Disable masks of check DFC_ComCANG3_HDL11TO" VALUE 0x8028376C Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_DisblMsk.DFC_ComCANG3_HDL12TO_C "DFC / Disable masks of check DFC_ComCANG3_HDL12TO" VALUE 0x8028376E Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_DisblMsk.DFC_ComCANG3_HDL13TO_C "DFC / Disable masks of check DFC_ComCANG3_HDL13TO" VALUE 0x80283770 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_DisblMsk.DFC_ComCANG3_HDL14TO_C "DFC / Disable masks of check DFC_ComCANG3_HDL14TO" VALUE 0x80283772 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_DisblMsk.DFC_ComCANG3_HDL15TO_C "DFC / Disable masks of check DFC_ComCANG3_HDL15TO" VALUE 0x80283774 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_DisblMsk.DFC_ComCANG3_HDL16TO_C "DFC / Disable masks of check DFC_ComCANG3_HDL16TO" VALUE 0x80283776 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_DisblMsk.DFC_ComCANG3_HDL17TO_C "DFC / Disable masks of check DFC_ComCANG3_HDL17TO" VALUE 0x80283778 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_DisblMsk.DFC_ComCANG3_HDL18TO_C "DFC / Disable masks of check DFC_ComCANG3_HDL18TO" VALUE 0x8028377A Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_DisblMsk.DFC_ComCANG3_HDL19TO_C "DFC / Disable masks of check DFC_ComCANG3_HDL19TO" VALUE 0x8028377C Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_DisblMsk.DFC_ComCANG3_HDL1TO_C "DFC / Disable masks of check DFC_ComCANG3_HDL1TO" VALUE 0x8028377E Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_DisblMsk.DFC_ComCANG3_HDL20TO_C "DFC / Disable masks of check DFC_ComCANG3_HDL20TO" VALUE 0x80283780 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_DisblMsk.DFC_ComCANG3_HDL21TO_C "DFC / Disable masks of check DFC_ComCANG3_HDL21TO" VALUE 0x80283782 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_DisblMsk.DFC_ComCANG3_HDL22TO_C "DFC / Disable masks of check DFC_ComCANG3_HDL22TO" VALUE 0x80283784 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_DisblMsk.DFC_ComCANG3_HDL23TO_C "DFC / Disable masks of check DFC_ComCANG3_HDL23TO" VALUE 0x80283786 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_DisblMsk.DFC_ComCANG3_HDL24TO_C "DFC / Disable masks of check DFC_ComCANG3_HDL24TO" VALUE 0x80283788 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_DisblMsk.DFC_ComCANG3_HDL2TO_C "DFC / Disable masks of check DFC_ComCANG3_HDL2TO" VALUE 0x8028378A Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_DisblMsk.DFC_ComCANG3_HDL3TO_C "DFC / Disable masks of check DFC_ComCANG3_HDL3TO" VALUE 0x8028378C Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_DisblMsk.DFC_ComCANG3_HDL4TO_C "DFC / Disable masks of check DFC_ComCANG3_HDL4TO" VALUE 0x8028378E Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_DisblMsk.DFC_ComCANG3_HDL5TO_C "DFC / Disable masks of check DFC_ComCANG3_HDL5TO" VALUE 0x80283790 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_DisblMsk.DFC_ComCANG3_HDL6TO_C "DFC / Disable masks of check DFC_ComCANG3_HDL6TO" VALUE 0x80283792 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_DisblMsk.DFC_ComCANG3_HDL7TO_C "DFC / Disable masks of check DFC_ComCANG3_HDL7TO" VALUE 0x80283794 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_DisblMsk.DFC_ComCANG3_HDL8TO_C "DFC / Disable masks of check DFC_ComCANG3_HDL8TO" VALUE 0x80283796 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_DisblMsk.DFC_ComCANG3_HDL9TO_C "DFC / Disable masks of check DFC_ComCANG3_HDL9TO" VALUE 0x80283798 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_DisblMsk.DFC_ComCANG4_HDL0TO_C "DFC / Disable masks of check DFC_ComCANG4_HDL0TO" VALUE 0x8028379A Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_DisblMsk.DFC_ComCANG4_HDL10TO_C "DFC / Disable masks of check DFC_ComCANG4_HDL10TO" VALUE 0x8028379C Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_DisblMsk.DFC_ComCANG4_HDL11TO_C "DFC / Disable masks of check DFC_ComCANG4_HDL11TO" VALUE 0x8028379E Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_DisblMsk.DFC_ComCANG4_HDL12TO_C "DFC / Disable masks of check DFC_ComCANG4_HDL12TO" VALUE 0x802837A0 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_DisblMsk.DFC_ComCANG4_HDL13TO_C "DFC / Disable masks of check DFC_ComCANG4_HDL13TO" VALUE 0x802837A2 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_DisblMsk.DFC_ComCANG4_HDL14TO_C "DFC / Disable masks of check DFC_ComCANG4_HDL14TO" VALUE 0x802837A4 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_DisblMsk.DFC_ComCANG4_HDL15TO_C "DFC / Disable masks of check DFC_ComCANG4_HDL15TO" VALUE 0x802837A6 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_DisblMsk.DFC_ComCANG4_HDL16TO_C "DFC / Disable masks of check DFC_ComCANG4_HDL16TO" VALUE 0x802837A8 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_DisblMsk.DFC_ComCANG4_HDL17TO_C "DFC / Disable masks of check DFC_ComCANG4_HDL17TO" VALUE 0x802837AA Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_DisblMsk.DFC_ComCANG4_HDL18TO_C "DFC / Disable masks of check DFC_ComCANG4_HDL18TO" VALUE 0x802837AC Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_DisblMsk.DFC_ComCANG4_HDL19TO_C "DFC / Disable masks of check DFC_ComCANG4_HDL19TO" VALUE 0x802837AE Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_DisblMsk.DFC_ComCANG4_HDL1TO_C "DFC / Disable masks of check DFC_ComCANG4_HDL1TO" VALUE 0x802837B0 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_DisblMsk.DFC_ComCANG4_HDL20TO_C "DFC / Disable masks of check DFC_ComCANG4_HDL20TO" VALUE 0x802837B2 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_DisblMsk.DFC_ComCANG4_HDL21TO_C "DFC / Disable masks of check DFC_ComCANG4_HDL21TO" VALUE 0x802837B4 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_DisblMsk.DFC_ComCANG4_HDL22TO_C "DFC / Disable masks of check DFC_ComCANG4_HDL22TO" VALUE 0x802837B6 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_DisblMsk.DFC_ComCANG4_HDL23TO_C "DFC / Disable masks of check DFC_ComCANG4_HDL23TO" VALUE 0x802837B8 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_DisblMsk.DFC_ComCANG4_HDL24TO_C "DFC / Disable masks of check DFC_ComCANG4_HDL24TO" VALUE 0x802837BA Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_DisblMsk.DFC_ComCANG4_HDL2TO_C "DFC / Disable masks of check DFC_ComCANG4_HDL2TO" VALUE 0x802837BC Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_DisblMsk.DFC_ComCANG4_HDL3TO_C "DFC / Disable masks of check DFC_ComCANG4_HDL3TO" VALUE 0x802837BE Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_DisblMsk.DFC_ComCANG4_HDL4TO_C "DFC / Disable masks of check DFC_ComCANG4_HDL4TO" VALUE 0x802837C0 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFC_DisblMsk.DFC_ComCANG4_HDL5TO_C "DFC / Disable masks of check DFC_ComCANG4_HDL5TO" VALUE 0x802837C2 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin COMPU_METHOD Area_cm2 "" RAT_FUNC "%6.5" "cm*cm" COEFFS 0 1000 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD Area_cm2_float "" RAT_FUNC "%6.2" "cm*cm" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD Area_cm2_Low "" RAT_FUNC "%6.4" "cm*cm" COEFFS 0 250 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD AshEGMassPerTime "" RAT_FUNC "%6.5" "mg/s" COEFFS 0 2000 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD AshMassPerTime "" RAT_FUNC "%6.4" "mg/s" COEFFS 0 100 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD AshMs_g_p0q1_COMPU "" RAT_FUNC "%6.3" "g" COEFFS 0 10 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD AshMs_mg_p0q0016_COMPU "" RAT_FUNC "%6.4" "mg" COEFFS 0 625 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD ASModPrcPerSec_COMPU "" RAT_FUNC "%6.3" "%/s" COEFFS 0 1.6384 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD BBSTVE_SY_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF BBSTVE_SY_Compu /end COMPU_METHOD
/begin COMPU_VTAB BBSTVE_SY_Compu "" TAB_VERB 2 0 "False" 1 "True" /end COMPU_VTAB
/begin COMPU_METHOD BSP742_SY_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF BSP742_SY_Compu /end COMPU_METHOD
/begin COMPU_VTAB BSP742_SY_Compu "" TAB_VERB 2 0 "no BSP742" 1 "one BSP742" /end COMPU_VTAB
/begin COMPU_METHOD BYPASS_SY_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF BYPASS_SY_Compu /end COMPU_METHOD
/begin COMPU_VTAB BYPASS_SY_Compu "" TAB_VERB 2 0 "No Bypass" 1 "Bypass" /end COMPU_VTAB
/begin COMPU_METHOD CABVLV_TYPAVLACTRLIB_SY_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF CABVLV_TYPAVLACTRLIB_SY_Compu /end COMPU_METHOD
/begin COMPU_VTAB CABVLV_TYPAVLACTRLIB_SY_Compu "" TAB_VERB 2 0 "FALSE" 1 "TRUE" /end COMPU_VTAB
/begin COMPU_METHOD Calory "" RAT_FUNC "%6.2" "J/g" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD CalVal_q0p01 "" RAT_FUNC "%6.4" "MJ/Kg" COEFFS 0 100 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD CALWUP_SY_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF CALWUP_SY_Compu /end COMPU_METHOD
/begin COMPU_VTAB CALWUP_SY_Compu "" TAB_VERB 2 0 "no calibration wake up" 1 "calibration wake up" /end COMPU_VTAB
/begin COMPU_METHOD CAN_MONITORING_ENBLD_SY_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF CAN_MONITORING_ENBLD_SY_Compu /end COMPU_METHOD
/begin COMPU_VTAB CAN_MONITORING_ENBLD_SY_Compu "" TAB_VERB 2 0 "DISABLED" 1 "ENABLED" /end COMPU_VTAB
/begin COMPU_METHOD CAN_MULTIPLEXSORT_ENBLD_SY_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF CAN_MULTIPLEXSORT_ENBLD_SY_Compu /end COMPU_METHOD
/begin COMPU_VTAB CAN_MULTIPLEXSORT_ENBLD_SY_Compu "" TAB_VERB 2 0 "DISABLED" 1 "ENABLED" /end COMPU_VTAB
/begin COMPU_METHOD CASI1_SSP_SY_Compu "" RAT_FUNC "%6.2" "" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD CASI2_SSP_SY_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF CASI2_SSP_SY_Compu /end COMPU_METHOD
/begin COMPU_VTAB CASI2_SSP_SY_Compu "" TAB_VERB 4 0 "NO_CAS_SSPMON" 1 "SSPMON1" 2 "SSPMON2" 3 "SSPMON3" /end COMPU_VTAB
/begin COMPU_METHOD CASO1_SSP_SY_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF CASO1_SSP_SY_Compu /end COMPU_METHOD
/begin COMPU_VTAB CASO1_SSP_SY_Compu "" TAB_VERB 4 0 "NO_CAS_SSPMON" 1 "SSPMON1" 2 "SSPMON2" 3 "SSPMON3" /end COMPU_VTAB
/begin COMPU_METHOD CASO2_SSP_SY_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF CASO2_SSP_SY_Compu /end COMPU_METHOD
/begin COMPU_VTAB CASO2_SSP_SY_Compu "" TAB_VERB 4 0 "NO_CAS_SSPMON" 1 "SSPMON1" 2 "SSPMON2" 3 "SSPMON3" /end COMPU_VTAB
/begin COMPU_METHOD CASTYP_SY_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF CASTYP_SY_Compu /end COMPU_METHOD
/begin COMPU_VTAB CASTYP_SY_Compu "" TAB_VERB 7 0 "individual camshaft" 1 "CAMSHAFT_4TOOTH" 2 "CAMSHAFT_3TOOTH_4Segment" 3 "CAMSHAFT_IMPULSE" 4 "CAMSHAFT_HALFMOON" 5 "CAMSHAFT_5TOOTH" 6 "CAMSHAFT_DSSTD" /end COMPU_VTAB
/begin COMPU_METHOD CAS_ADAP_SY_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF CAS_ADAP_SY_Compu /end COMPU_METHOD
/begin COMPU_VTAB CAS_ADAP_SY_Compu "" TAB_VERB 4 0 "0" 1 "1" 2 "2" 3 "3" /end COMPU_VTAB
/begin COMPU_METHOD CAS_ANGLE_SY_Compu "" RAT_FUNC "%6.2" "" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD CAS_BACKUPVAR_SY_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF CAS_BACKUPVAR_SY_Compu /end COMPU_METHOD
/begin COMPU_VTAB CAS_BACKUPVAR_SY_Compu "" TAB_VERB 2 0 "False" 1 "True" /end COMPU_VTAB
/begin COMPU_METHOD CAS_BACKUP_SY_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF CAS_BACKUP_SY_Compu /end COMPU_METHOD
/begin COMPU_VTAB CAS_BACKUP_SY_Compu "" TAB_VERB 5 0 "NO_BACKUP" 1 "TST_INJ" 2 "DOUBLE_IGN" 3 "TST_INJ_GDI" 4 "TST_INJ_DS" /end COMPU_VTAB
/begin COMPU_METHOD CAS_DELAY_SC_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF CAS_DELAY_SC_Compu /end COMPU_METHOD
/begin COMPU_VTAB CAS_DELAY_SC_Compu "" TAB_VERB 2 0 "NO_DELAY" 1 "DELAY" /end COMPU_VTAB
/begin COMPU_METHOD CAS_DIAG_SY_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF CAS_DIAG_SY_Compu /end COMPU_METHOD
/begin COMPU_VTAB CAS_DIAG_SY_Compu "" TAB_VERB 4 0 "0" 1 "1" 2 "2" 3 "3" /end COMPU_VTAB
/begin COMPU_METHOD CAS_I1_SY_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF CAS_I1_SY_Compu /end COMPU_METHOD
/begin COMPU_VTAB CAS_I1_SY_Compu "" TAB_VERB 2 0 "Signal ist nicht vorhanden" 1 "Signal ist vorhanden" /end COMPU_VTAB
/begin COMPU_METHOD CAS_I2_SY_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF CAS_I2_SY_Compu /end COMPU_METHOD
/begin COMPU_VTAB CAS_I2_SY_Compu "" TAB_VERB 2 0 "Signal ist nicht vorhanden" 1 "Signal ist vorhanden" /end COMPU_VTAB
/begin COMPU_METHOD CAS_O1_SY_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF CAS_O1_SY_Compu /end COMPU_METHOD
/begin COMPU_VTAB CAS_O1_SY_Compu "" TAB_VERB 2 0 "Signal ist nicht vorhanden" 1 "Signal ist vorhanden" /end COMPU_VTAB
/begin COMPU_METHOD CAS_O2_SY_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF CAS_O2_SY_Compu /end COMPU_METHOD
/begin COMPU_VTAB CAS_O2_SY_Compu "" TAB_VERB 2 0 "Signal ist nicht vorhanden" 1 "Signal ist vorhanden" /end COMPU_VTAB
/begin COMPU_METHOD CAS_OUT_SY_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF CAS_OUT_SY_Compu /end COMPU_METHOD
/begin COMPU_VTAB CAS_OUT_SY_Compu "" TAB_VERB 3 0 "NO_CAS_OUTPUT" 1 "OUTPUT_VAR1" 2 "OUTPUT_VAR2" /end COMPU_VTAB
/begin COMPU_METHOD CAS_SEGCOR_SY_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF CAS_SEGCOR_SY_Compu /end COMPU_METHOD
/begin COMPU_VTAB CAS_SEGCOR_SY_Compu "" TAB_VERB 2 0 "0" 1 "1" /end COMPU_VTAB
/begin COMPU_METHOD Ch_Ah_q0p5_COMPU "" RAT_FUNC "%6.3" "Ah" COEFFS 0 2 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD CIC751_SY_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF CIC751_SY_Compu /end COMPU_METHOD
/begin COMPU_VTAB CIC751_SY_Compu "" TAB_VERB 2 0 "no CIC751" 1 "one CIC751" /end COMPU_VTAB
/begin COMPU_METHOD CJ930_NUMCHP_SY_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF CJ930_NUMCHP_SY_Compu /end COMPU_METHOD
/begin COMPU_VTAB CJ930_NUMCHP_SY_Compu "" TAB_VERB 2 0 "no CJ930 in ECU" 1 "one CJ930 in ECU" /end COMPU_VTAB
/begin COMPU_METHOD CJ930_SY_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF CJ930_SY_Compu /end COMPU_METHOD
/begin COMPU_VTAB CJ930_SY_Compu "" TAB_VERB 2 0 "no CJ930" 1 "one CJ930" /end COMPU_VTAB
/begin COMPU_METHOD CJ945_SY_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF CJ945_SY_Compu /end COMPU_METHOD
/begin COMPU_VTAB CJ945_SY_Compu "" TAB_VERB 3 0 "no CJ945" 1 "one CJ945" 2 "two CJ945" /end COMPU_VTAB
/begin COMPU_METHOD CJ950_SY_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF CJ950_SY_Compu /end COMPU_METHOD
/begin COMPU_VTAB CJ950_SY_Compu "" TAB_VERB 5 0 "NO_CJ950" 1 "1_CJ950" 2 "2_CJ950" 3 "3_CJ950" 4 "4_CJ950" /end COMPU_VTAB
/begin COMPU_METHOD CmbNoi "" RAT_FUNC "%6.5" "-" COEFFS 0 1024 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD CMBTYP_SY_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF CMBTYP_SY_Compu /end COMPU_METHOD
/begin COMPU_VTAB CMBTYP_SY_Compu "" TAB_VERB 2 0 "CMBTYP_DS" 1 "CMBTYP_GS" /end COMPU_VTAB
/begin COMPU_METHOD CnvtCoeffCatAir "" RAT_FUNC "%6.4" "J/K/s/m^2" COEFFS 0 50 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD CoeffA "" RAT_FUNC "%6.4" "1/(s*Nm)" COEFFS 0 204.8 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD CoEOMSwt "" RAT_FUNC "%10.9" "-" COEFFS 0 16384000 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD CoEOMSwt_S16 "" RAT_FUNC "%7.6" "-" COEFFS 0 16384 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD COESS_RCPTMNG_SY_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF COESS_RCPTMNG_SY_Compu /end COMPU_METHOD
/begin COMPU_VTAB COESS_RCPTMNG_SY_Compu "" TAB_VERB 2 0 "False" 1 "True" /end COMPU_VTAB
/begin COMPU_METHOD COMassPerTime "" RAT_FUNC "%6.4" "mg/s" COEFFS 0 20 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD CppFacCylVol "" RAT_FUNC "%7.6" "-" COEFFS 0 32768 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD CppOfsFact "" RAT_FUNC "%6.4" "-" COEFFS 0 256 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD CRSSENSTYP_SY_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF CRSSENSTYP_SY_Compu /end COMPU_METHOD
/begin COMPU_VTAB CRSSENSTYP_SY_Compu "" TAB_VERB 2 0 "STD" 1 "DGI" /end COMPU_VTAB
/begin COMPU_METHOD CRSTYP_SY_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF CRSTYP_SY_Compu /end COMPU_METHOD
/begin COMPU_VTAB CRSTYP_SY_Compu "" TAB_VERB 3 0 "standard flywheel" 1 "12°-gap" 2 "coded gap" /end COMPU_VTAB
/begin COMPU_METHOD CRS_ALTPIN_SY_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF CRS_ALTPIN_SY_Compu /end COMPU_METHOD
/begin COMPU_VTAB CRS_ALTPIN_SY_Compu "" TAB_VERB 2 0 "False" 1 "True" /end COMPU_VTAB
/begin COMPU_METHOD CRS_ANGLECOR_SY_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF CRS_ANGLECOR_SY_Compu /end COMPU_METHOD
/begin COMPU_VTAB CRS_ANGLECOR_SY_Compu "" TAB_VERB 4 0 "no correction" 1 "IAS" 2 "IAP" 3 "IAS & IAP" /end COMPU_VTAB
/begin COMPU_METHOD CRS_BACKUP_CASTYP_SY_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF CRS_BACKUP_CASTYP_SY_Compu /end COMPU_METHOD
/begin COMPU_VTAB CRS_BACKUP_CASTYP_SY_Compu "" TAB_VERB 3 0 "0" 1 "1" 2 "2" /end COMPU_VTAB
/begin COMPU_METHOD CRS_BACKUP_DYN_SY_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF CRS_BACKUP_DYN_SY_Compu /end COMPU_METHOD
/begin COMPU_VTAB CRS_BACKUP_DYN_SY_Compu "" TAB_VERB 2 0 "CAL_DYNCOR" 1 "ADAP_DYNCAOR" /end COMPU_VTAB
/begin COMPU_METHOD CRS_BACKUP_SY_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF CRS_BACKUP_SY_Compu /end COMPU_METHOD
/begin COMPU_VTAB CRS_BACKUP_SY_Compu "" TAB_VERB 4 0 "0" 1 "1" 2 "2" 3 "3" /end COMPU_VTAB
/begin COMPU_METHOD CRS_CY30CONF_SY_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF CRS_CY30CONF_SY_Compu /end COMPU_METHOD
/begin COMPU_VTAB CRS_CY30CONF_SY_Compu "" TAB_VERB 4 0 "hard wired" 1 "Conf_TH set from SW" 2 "Conf_K set from SW" 3 "Conf_K and Conf TH set from SW" /end COMPU_VTAB
/begin COMPU_METHOD CRS_DIAG_DETAIL_SY_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF CRS_DIAG_DETAIL_SY_Compu /end COMPU_METHOD
/begin COMPU_VTAB CRS_DIAG_DETAIL_SY_Compu "" TAB_VERB 3 0 "NO_DETAIL" 1 "DETAIL_ERRSIG" 2 "DETAIL_ERRSIG_GLITCH" /end COMPU_VTAB
/begin COMPU_METHOD CRS_DIAG_SYNCINJLOST_SY_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF CRS_DIAG_SYNCINJLOST_SY_Compu /end COMPU_METHOD
/begin COMPU_VTAB CRS_DIAG_SYNCINJLOST_SY_Compu "" TAB_VERB 2 0 "NO_ADD_DIAG" 1 "ACTIVATED" /end COMPU_VTAB
/begin COMPU_METHOD CRS_MIAP_SY_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF CRS_MIAP_SY_Compu /end COMPU_METHOD
/begin COMPU_VTAB CRS_MIAP_SY_Compu "" TAB_VERB 2 0 "False" 1 "True" /end COMPU_VTAB
/begin COMPU_METHOD CRS_SSP_SY_Compu "" RAT_FUNC "%6.2" "" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD CRS_TAA_SY_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF CRS_TAA_SY_Compu /end COMPU_METHOD
/begin COMPU_VTAB CRS_TAA_SY_Compu "" TAB_VERB 2 0 "False" 1 "True" /end COMPU_VTAB
/begin COMPU_METHOD CRS_TOOTHAVRG_SY_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF CRS_TOOTHAVRG_SY_Compu /end COMPU_METHOD
/begin COMPU_VTAB CRS_TOOTHAVRG_SY_Compu "" TAB_VERB 2 0 "False" 1 "True" /end COMPU_VTAB
/begin COMPU_METHOD CubMtrPerHr "" RAT_FUNC "%6.3" "m^3/h" COEFFS 0 10 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD Curr "" RAT_FUNC "%6.2" "mA" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD Curr_A "" RAT_FUNC "%6.4" "A" COEFFS 0 100 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD CVOCFG_SC_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF CVOCFG_SC_Compu /end COMPU_METHOD
/begin COMPU_VTAB CVOCFG_SC_Compu "" TAB_VERB 2 0 "NO_CVO" 1 "BASC_CVO" /end COMPU_VTAB
/begin COMPU_METHOD CY100_SY_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF CY100_SY_Compu /end COMPU_METHOD
/begin COMPU_VTAB CY100_SY_Compu "" TAB_VERB 3 0 "no CY100" 1 "one CY100" 2 "two CY100" /end COMPU_VTAB
/begin COMPU_METHOD CY141_SY_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF CY141_SY_Compu /end COMPU_METHOD
/begin COMPU_VTAB CY141_SY_Compu "" TAB_VERB 2 0 "no CY141" 1 "one CY141" /end COMPU_VTAB
/begin COMPU_METHOD CY146_SY_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF CY146_SY_Compu /end COMPU_METHOD
/begin COMPU_VTAB CY146_SY_Compu "" TAB_VERB 2 0 "no CY146" 1 "one CY146" /end COMPU_VTAB
/begin COMPU_METHOD CY320_SY_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF CY320_SY_Compu /end COMPU_METHOD
/begin COMPU_VTAB CY320_SY_Compu "" TAB_VERB 2 0 "0" 1 "1" /end COMPU_VTAB
/begin COMPU_METHOD CY327_SY_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF CY327_SY_Compu /end COMPU_METHOD
/begin COMPU_VTAB CY327_SY_Compu "" TAB_VERB 3 0 "No CY327" 1 "One CY327" 2 "Two CY327" /end COMPU_VTAB
/begin COMPU_METHOD CylHtRls "" RAT_FUNC "%6.3" "J" COEFFS 0 4 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD DDRCTime_ms "" RAT_FUNC "%6.1" "ms" COEFFS 0 1 0 0 0 10 /end COMPU_METHOD
/begin COMPU_METHOD DDRC_Ratio "" TAB_VERB "%6.3" "-" COMPU_TAB_REF DDRC_Ratio /end COMPU_METHOD
/begin COMPU_VTAB DDRC_Ratio "" TAB_VERB 4 1 "Ratio1" 2 "Ratio2" 3 "Ratio3" 4 "Ratio4" /end COMPU_VTAB
/begin COMPU_METHOD DFES_OneToOne "" RAT_FUNC "%6.2" "-" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD Fact "" RAT_FUNC "%6.5" "-" COEFFS 0 8192 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD OneToOne "" RAT_FUNC "%6.2" "No Unit" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD Volt_Batt "" RAT_FUNC "%6.1" "mV" COEFFS 0 0.05 0 0 0 1 /end COMPU_METHOD
/begin RECORD_LAYOUT Kw_Ws16 FNC_VALUES 1 SWORD COLUMN_DIR DIRECT /end RECORD_LAYOUT
/begin RECORD_LAYOUT Val_Wu16 FNC_VALUES 1 UWORD COLUMN_DIR DIRECT /end RECORD_LAYOUT
/begin RECORD_LAYOUT Val_Wu8 FNC_VALUES 1 UBYTE COLUMN_DIR DIRECT /end RECORD_LAYOUT
/end MODULE
/end PROJECT
