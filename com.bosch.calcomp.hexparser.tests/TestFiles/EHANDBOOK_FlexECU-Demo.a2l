ASAP2_VERSION 1 4
/begin PROJECT MED1734_Flx_G1 "MEDC17_Core"
/begin HEADER "" VERSION "MED1734_Flx_01" PROJECT_NO MED1734_Flx_G1 /end HEADER
/begin MODULE DIM ""
/begin MOD_COMMON "" BYTE_ORDER MSB_LAST ALIGNMENT_BYTE 1 ALIGNMENT_WORD 2 ALIGNMENT_LONG 4 ALIGNMENT_FLOAT32_IEEE 4 /end MOD_COMMON
/begin MEASUREMENT DFES_ISOFrstCnfDFC "" UWORD DFCDFP_Verb 1 100 0.00 527. FORMAT "%2.0" ECU_ADDRESS 0xD001AF76 /end MEASUREMENT
/begin MEASUREMENT DFES_ISOFrstFailDFC "" UWORD DFCDFP_Verb 1 100 0.00 527. FORMAT "%2.0" ECU_ADDRESS 0xD001AF72 /end MEASUREMENT
/begin MEASUREMENT DFES_ISORcntCnfDFC "" UWORD DFCDFP_Verb 1 100 0.00 527. FORMAT "%2.0" ECU_ADDRESS 0xD001AF78 /end MEASUREMENT
/begin MEASUREMENT DFES_ISORcntFailDFC "" UWORD DFCDFP_Verb 1 100 0.00 527. FORMAT "%2.0" ECU_ADDRESS 0xD001AF74 /end MEASUREMENT
/begin MEASUREMENT DFES_MonEvnt "" UWORD DFES_Mon_Verb 1 100 0.00 32783.0000000 FORMAT "%13.7" ARRAY_SIZE 2 ECU_ADDRESS 0xD001AF54 /end MEASUREMENT
/begin MEASUREMENT DFES_MonObjt "" UWORD OneToOne 1 100 0.00 65535.00 FORMAT "%8.2" ARRAY_SIZE 2 ECU_ADDRESS 0xD001AF58 /end MEASUREMENT
/begin MEASUREMENT DFES_MonParm "" UWORD OneToOne 1 100 0.00 65535.00 FORMAT "%8.2" ARRAY_SIZE 2 ECU_ADDRESS 0xD001AF5C /end MEASUREMENT
/begin MEASUREMENT DFES_MonPtr "" UBYTE DFES_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AF52 /end MEASUREMENT
/begin MEASUREMENT DFES_numDFC "" UWORD DFCDFP_Verb 1 100 0.00 527. FORMAT "%2.0" ARRAY_SIZE 10 ECU_ADDRESS 0xD001AF7A /end MEASUREMENT
/begin MEASUREMENT DFES_numEntryAvl "" UBYTE DFES_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001733E /end MEASUREMENT
/begin MEASUREMENT DFES_numEnvSize "" UBYTE DFES_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0017341 /end MEASUREMENT
/begin MEASUREMENT DFES_numExtdFrzFrmSize "" UBYTE DFES_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0017340 /end MEASUREMENT
/begin MEASUREMENT DFES_numFrzFrmSize "" UBYTE DFES_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001733F /end MEASUREMENT
/begin MEASUREMENT DFES_Order "" UWORD DFES_OneToOne 1 100 0.00 65535.00 FORMAT "%8.2" ARRAY_SIZE 10 ECU_ADDRESS 0xD0016AFE /end MEASUREMENT
/begin MEASUREMENT DFES_OutLamps "" UBYTE DFES_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ARRAY_SIZE 10 ECU_ADDRESS 0xD00172FB /end MEASUREMENT
/begin MEASUREMENT DFES_OutTester "" UBYTE DFES_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ARRAY_SIZE 10 ECU_ADDRESS 0xD0017305 /end MEASUREMENT
/begin MEASUREMENT DFES_PDTCStore "" UBYTE OneToOne 1 100 0.00 1.000 BIT_MASK 0x1 FORMAT "%5.3" ECU_ADDRESS 0xD0001925 /end MEASUREMENT
/begin MEASUREMENT DFES_stChk "" UBYTE DFES_stCheck_Verb 1 100 0.00 247.000000000 FORMAT "%13.9" ARRAY_SIZE 10 ECU_ADDRESS 0xD001AF98 /end MEASUREMENT
/begin MEASUREMENT DFES_stChkFault "" UBYTE DFES_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ARRAY_SIZE 10 ECU_ADDRESS 0xD001AFA2 /end MEASUREMENT
/begin MEASUREMENT DFES_stCounters "" UBYTE DFES_stCnt_Verb 1 100 0.00 85.0000000000 FORMAT "%13.10" ARRAY_SIZE 10 ECU_ADDRESS 0xD001AFAC /end MEASUREMENT
/begin MEASUREMENT DFES_stCtlSetting "" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0016FDF /end MEASUREMENT
/begin MEASUREMENT DFES_stEntry "" UBYTE DFES_stEntry_Verb 1 100 0.00 254.000000000 FORMAT "%13.9" ARRAY_SIZE 10 ECU_ADDRESS 0xD001AF8E /end MEASUREMENT
/begin MEASUREMENT DFES_stErrDia "" UBYTE DFES_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0017338 /end MEASUREMENT
/begin MEASUREMENT DFES_stErrLamp "" UBYTE DFES_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0017337 /end MEASUREMENT
/begin MEASUREMENT DFES_stOutstate "" UBYTE DFES_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0017342 /end MEASUREMENT
/begin MEASUREMENT DFES_stPrgEvt "" UBYTE OneToOne 1 100 0.00 1.000 BIT_MASK 0x8 FORMAT "%5.3" ECU_ADDRESS 0xD0001924 /end MEASUREMENT
/begin MEASUREMENT dfrsna2_w "" SWORD fak_sw_b1 1 100 -1.000000 0.9999695 FORMAT "%8.6" ECU_ADDRESS 0xD0000C70 /end MEASUREMENT
/begin MEASUREMENT dfrsna_w "" SWORD fak_sw_b1 1 100 -1.000000 0.9999695 FORMAT "%8.6" ECU_ADDRESS 0xD0000C72 /end MEASUREMENT
/begin MEASUREMENT DHELSF.B_hsok "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x2 FORMAT "%13.11" ECU_ADDRESS 0xD000055A /end MEASUREMENT
/begin MEASUREMENT DHELSF.B_mnfhs_FF.status "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD000055E /end MEASUREMENT
/begin MEASUREMENT DHELSF.B_mxfhs_FF.status "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD000055F /end MEASUREMENT
/begin MEASUREMENT DHELSF.B_sifhs_FF.status "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD0000560 /end MEASUREMENT
/begin MEASUREMENT DHELSF.hater_off_FF.status "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD0000564 /end MEASUREMENT
/begin MEASUREMENT DHELSF.healee_TONV.outbit "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD0000566 /end MEASUREMENT
/begin MEASUREMENT DHELSF.healee_TONV.time "" UBYTE t_q0p05 1 100 0.00 12.75 FORMAT "%5.2" ECU_ADDRESS 0xD0000567 /end MEASUREMENT
/begin MEASUREMENT DHELSF.heater_on_FF.status "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD0000568 /end MEASUREMENT
/begin MEASUREMENT DHELSF.max_TONV.outbit "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD000056A /end MEASUREMENT
/begin MEASUREMENT DHELSF.max_TONV.time "" UBYTE t_q0p05 1 100 0.00 12.75 FORMAT "%5.2" ECU_ADDRESS 0xD000056B /end MEASUREMENT
/begin MEASUREMENT DHELSF.min_TONV.outbit "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD000056C /end MEASUREMENT
/begin MEASUREMENT DHELSF.min_TONV.time "" UBYTE t_q0p05 1 100 0.00 12.75 FORMAT "%5.2" ECU_ADDRESS 0xD000056D /end MEASUREMENT
/begin MEASUREMENT DHELSF.sig_TONV.outbit "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD000056E /end MEASUREMENT
/begin MEASUREMENT DHELSF.sig_TONV.time "" UBYTE t_q0p05 1 100 0.00 12.75 FORMAT "%5.2" ECU_ADDRESS 0xD000056F /end MEASUREMENT
/begin MEASUREMENT DHELSF.tvmn_TONV.outbit "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD0000570 /end MEASUREMENT
/begin MEASUREMENT DHELSF.tvmn_TONV.time "" UBYTE t_q0p01 1 100 0.00 2.550 FORMAT "%5.3" ECU_ADDRESS 0xD0000571 /end MEASUREMENT
/begin MEASUREMENT DHELSF.tvmx_TONV.outbit "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD0000572 /end MEASUREMENT
/begin MEASUREMENT DHELSF.tvmx_TONV.time "" UBYTE t_q0p01 1 100 0.00 2.550 FORMAT "%5.3" ECU_ADDRESS 0xD0000573 /end MEASUREMENT
/begin MEASUREMENT DHELSF.tvsi_TONV.outbit "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD0000574 /end MEASUREMENT
/begin MEASUREMENT DHELSF.tvsi_TONV.time "" UBYTE t_q0p01 1 100 0.00 2.550 FORMAT "%5.3" ECU_ADDRESS 0xD0000575 /end MEASUREMENT
/begin MEASUREMENT DHELSF2.B_hsok "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x2 FORMAT "%13.11" ECU_ADDRESS 0xD0000578 /end MEASUREMENT
/begin MEASUREMENT DHELSF2.B_mnfhs_FF.status "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD000057C /end MEASUREMENT
/begin MEASUREMENT DHELSF2.B_mxfhs_FF.status "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD000057D /end MEASUREMENT
/begin MEASUREMENT DHELSF2.B_sifhs_FF.status "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD000057E /end MEASUREMENT
/begin MEASUREMENT DHELSF2.hater_off_FF.status "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD0000582 /end MEASUREMENT
/begin MEASUREMENT DHELSF2.healee_TONV.outbit "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD0000584 /end MEASUREMENT
/begin MEASUREMENT DHELSF2.healee_TONV.time "" UBYTE t_q0p05 1 100 0.00 12.75 FORMAT "%5.2" ECU_ADDRESS 0xD0000585 /end MEASUREMENT
/begin MEASUREMENT DHELSF2.heater_on_FF.status "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD0000586 /end MEASUREMENT
/begin MEASUREMENT DHELSF2.max_TONV.outbit "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD0000588 /end MEASUREMENT
/begin MEASUREMENT DHELSF2.max_TONV.time "" UBYTE t_q0p05 1 100 0.00 12.75 FORMAT "%5.2" ECU_ADDRESS 0xD0000589 /end MEASUREMENT
/begin MEASUREMENT DHELSF2.min_TONV.outbit "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD000058A /end MEASUREMENT
/begin MEASUREMENT DHELSF2.min_TONV.time "" UBYTE t_q0p05 1 100 0.00 12.75 FORMAT "%5.2" ECU_ADDRESS 0xD000058B /end MEASUREMENT
/begin MEASUREMENT DHELSF2.sig_TONV.outbit "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD000058C /end MEASUREMENT
/begin MEASUREMENT DHELSF2.sig_TONV.time "" UBYTE t_q0p05 1 100 0.00 12.75 FORMAT "%5.2" ECU_ADDRESS 0xD000058D /end MEASUREMENT
/begin MEASUREMENT DHELSF2.tvmn_TONV.outbit "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD000058E /end MEASUREMENT
/begin MEASUREMENT DHELSF2.tvmn_TONV.time "" UBYTE t_q0p01 1 100 0.00 2.550 FORMAT "%5.3" ECU_ADDRESS 0xD000058F /end MEASUREMENT
/begin MEASUREMENT DHELSF2.tvmx_TONV.outbit "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD0000590 /end MEASUREMENT
/begin MEASUREMENT DHELSF2.tvmx_TONV.time "" UBYTE t_q0p01 1 100 0.00 2.550 FORMAT "%5.3" ECU_ADDRESS 0xD0000591 /end MEASUREMENT
/begin MEASUREMENT DHELSF2.tvsi_TONV.outbit "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD0000592 /end MEASUREMENT
/begin MEASUREMENT DHELSF2.tvsi_TONV.time "" UBYTE t_q0p01 1 100 0.00 2.550 FORMAT "%5.3" ECU_ADDRESS 0xD0000593 /end MEASUREMENT
/begin MEASUREMENT DHELSH.B_hsok "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x2 FORMAT "%13.11" ECU_ADDRESS 0xD0000596 /end MEASUREMENT
/begin MEASUREMENT DHELSH.B_mnfhs_FF.status "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD000059A /end MEASUREMENT
/begin MEASUREMENT DHELSH.B_mxfhs_FF.status "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD000059B /end MEASUREMENT
/begin MEASUREMENT DHELSH.B_sifhs_FF.status "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD000059C /end MEASUREMENT
/begin MEASUREMENT DHELSH.hater_off_FF.status "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD00005A0 /end MEASUREMENT
/begin MEASUREMENT DHELSH.healee_TONV.outbit "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD00005A2 /end MEASUREMENT
/begin MEASUREMENT DHELSH.healee_TONV.time "" UBYTE t_q0p05 1 100 0.00 12.75 FORMAT "%5.2" ECU_ADDRESS 0xD00005A3 /end MEASUREMENT
/begin MEASUREMENT DHELSH.heater_on_FF.status "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD00005A4 /end MEASUREMENT
/begin MEASUREMENT DHELSH.max_TONV.outbit "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD00005A6 /end MEASUREMENT
/begin MEASUREMENT DHELSH.max_TONV.time "" UBYTE t_q0p05 1 100 0.00 12.75 FORMAT "%5.2" ECU_ADDRESS 0xD00005A7 /end MEASUREMENT
/begin MEASUREMENT DHELSH.min_TONV.outbit "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD00005A8 /end MEASUREMENT
/begin MEASUREMENT DHELSH.min_TONV.time "" UBYTE t_q0p05 1 100 0.00 12.75 FORMAT "%5.2" ECU_ADDRESS 0xD00005A9 /end MEASUREMENT
/begin MEASUREMENT DHELSH.sig_TONV.outbit "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD00005AA /end MEASUREMENT
/begin MEASUREMENT DHELSH.sig_TONV.time "" UBYTE t_q0p05 1 100 0.00 12.75 FORMAT "%5.2" ECU_ADDRESS 0xD00005AB /end MEASUREMENT
/begin MEASUREMENT DHELSH.tvmn_TONV.outbit "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD00005AC /end MEASUREMENT
/begin MEASUREMENT DHELSH.tvmn_TONV.time "" UBYTE t_q0p01 1 100 0.00 2.550 FORMAT "%5.3" ECU_ADDRESS 0xD00005AD /end MEASUREMENT
/begin MEASUREMENT DHELSH.tvmx_TONV.outbit "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD00005AE /end MEASUREMENT
/begin MEASUREMENT DHELSH.tvmx_TONV.time "" UBYTE t_q0p01 1 100 0.00 2.550 FORMAT "%5.3" ECU_ADDRESS 0xD00005AF /end MEASUREMENT
/begin MEASUREMENT DHELSH.tvsi_TONV.outbit "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD00005B0 /end MEASUREMENT
/begin MEASUREMENT DHELSH.tvsi_TONV.time "" UBYTE t_q0p01 1 100 0.00 2.550 FORMAT "%5.3" ECU_ADDRESS 0xD00005B1 /end MEASUREMENT
/begin MEASUREMENT DHELSH2.B_hsok "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x2 FORMAT "%13.11" ECU_ADDRESS 0xD00005B4 /end MEASUREMENT
/begin MEASUREMENT DHELSH2.B_mnfhs_FF.status "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD00005B8 /end MEASUREMENT
/begin MEASUREMENT DHELSH2.B_mxfhs_FF.status "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD00005B9 /end MEASUREMENT
/begin MEASUREMENT DHELSH2.B_sifhs_FF.status "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD00005BA /end MEASUREMENT
/begin MEASUREMENT DHELSH2.hater_off_FF.status "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD00005BE /end MEASUREMENT
/begin MEASUREMENT DHELSH2.healee_TONV.outbit "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD00005C0 /end MEASUREMENT
/begin MEASUREMENT DHELSH2.healee_TONV.time "" UBYTE t_q0p05 1 100 0.00 12.75 FORMAT "%5.2" ECU_ADDRESS 0xD00005C1 /end MEASUREMENT
/begin MEASUREMENT DHELSH2.heater_on_FF.status "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD00005C2 /end MEASUREMENT
/begin MEASUREMENT DHELSH2.max_TONV.outbit "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD00005C4 /end MEASUREMENT
/begin MEASUREMENT DHELSH2.max_TONV.time "" UBYTE t_q0p05 1 100 0.00 12.75 FORMAT "%5.2" ECU_ADDRESS 0xD00005C5 /end MEASUREMENT
/begin MEASUREMENT DHELSH2.min_TONV.outbit "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD00005C6 /end MEASUREMENT
/begin MEASUREMENT DHELSH2.min_TONV.time "" UBYTE t_q0p05 1 100 0.00 12.75 FORMAT "%5.2" ECU_ADDRESS 0xD00005C7 /end MEASUREMENT
/begin MEASUREMENT DHELSH2.sig_TONV.outbit "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD00005C8 /end MEASUREMENT
/begin MEASUREMENT DHELSH2.sig_TONV.time "" UBYTE t_q0p05 1 100 0.00 12.75 FORMAT "%5.2" ECU_ADDRESS 0xD00005C9 /end MEASUREMENT
/begin MEASUREMENT DHELSH2.tvmn_TONV.outbit "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD00005CA /end MEASUREMENT
/begin MEASUREMENT DHELSH2.tvmn_TONV.time "" UBYTE t_q0p01 1 100 0.00 2.550 FORMAT "%5.3" ECU_ADDRESS 0xD00005CB /end MEASUREMENT
/begin MEASUREMENT DHELSH2.tvmx_TONV.outbit "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD00005CC /end MEASUREMENT
/begin MEASUREMENT DHELSH2.tvmx_TONV.time "" UBYTE t_q0p01 1 100 0.00 2.550 FORMAT "%5.3" ECU_ADDRESS 0xD00005CD /end MEASUREMENT
/begin MEASUREMENT DHELSH2.tvsi_TONV.outbit "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD00005CE /end MEASUREMENT
/begin MEASUREMENT DHELSH2.tvsi_TONV.time "" UBYTE t_q0p01 1 100 0.00 2.550 FORMAT "%5.3" ECU_ADDRESS 0xD00005CF /end MEASUREMENT
/begin MEASUREMENT DHELSV.B_hsok "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x2 FORMAT "%13.11" ECU_ADDRESS 0xD00005D2 /end MEASUREMENT
/begin MEASUREMENT DHELSV.B_mnfhs_FF.status "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD00005D6 /end MEASUREMENT
/begin MEASUREMENT DHELSV.B_mxfhs_FF.status "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD00005D7 /end MEASUREMENT
/begin MEASUREMENT DHELSV.B_sifhs_FF.status "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD00005D8 /end MEASUREMENT
/begin MEASUREMENT DHELSV.hater_off_FF.status "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD00005DC /end MEASUREMENT
/begin MEASUREMENT DHELSV.healee_TONV.outbit "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD00005DE /end MEASUREMENT
/begin MEASUREMENT DHELSV.healee_TONV.time "" UBYTE t_q0p05 1 100 0.00 12.75 FORMAT "%5.2" ECU_ADDRESS 0xD00005DF /end MEASUREMENT
/begin MEASUREMENT DHELSV.heater_on_FF.status "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD00005E0 /end MEASUREMENT
/begin MEASUREMENT DHELSV.max_TONV.outbit "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD00005E2 /end MEASUREMENT
/begin MEASUREMENT DHELSV.max_TONV.time "" UBYTE t_q0p05 1 100 0.00 12.75 FORMAT "%5.2" ECU_ADDRESS 0xD00005E3 /end MEASUREMENT
/begin MEASUREMENT DHELSV.min_TONV.outbit "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD00005E4 /end MEASUREMENT
/begin MEASUREMENT DHELSV.min_TONV.time "" UBYTE t_q0p05 1 100 0.00 12.75 FORMAT "%5.2" ECU_ADDRESS 0xD00005E5 /end MEASUREMENT
/begin MEASUREMENT DHELSV.sig_TONV.outbit "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD00005E6 /end MEASUREMENT
/begin MEASUREMENT DHELSV.sig_TONV.time "" UBYTE t_q0p05 1 100 0.00 12.75 FORMAT "%5.2" ECU_ADDRESS 0xD00005E7 /end MEASUREMENT
/begin MEASUREMENT DHELSV.tvmn_TONV.outbit "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD00005E8 /end MEASUREMENT
/begin MEASUREMENT DHELSV.tvmn_TONV.time "" UBYTE t_q0p01 1 100 0.00 2.550 FORMAT "%5.3" ECU_ADDRESS 0xD00005E9 /end MEASUREMENT
/begin MEASUREMENT DHELSV.tvmx_TONV.outbit "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD00005EA /end MEASUREMENT
/begin MEASUREMENT DHELSV.tvmx_TONV.time "" UBYTE t_q0p01 1 100 0.00 2.550 FORMAT "%5.3" ECU_ADDRESS 0xD00005EB /end MEASUREMENT
/begin MEASUREMENT DHELSV.tvsi_TONV.outbit "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD00005EC /end MEASUREMENT
/begin MEASUREMENT DHELSV.tvsi_TONV.time "" UBYTE t_q0p01 1 100 0.00 2.550 FORMAT "%5.3" ECU_ADDRESS 0xD00005ED /end MEASUREMENT
/begin MEASUREMENT DHELSV2.B_hsok "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x2 FORMAT "%13.11" ECU_ADDRESS 0xD00005F0 /end MEASUREMENT
/begin MEASUREMENT DHELSV2.B_mnfhs_FF.status "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD00005F4 /end MEASUREMENT
/begin MEASUREMENT DHELSV2.B_mxfhs_FF.status "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD00005F5 /end MEASUREMENT
/begin MEASUREMENT DHELSV2.B_sifhs_FF.status "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD00005F6 /end MEASUREMENT
/begin MEASUREMENT DHELSV2.hater_off_FF.status "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD00005FA /end MEASUREMENT
/begin MEASUREMENT DHELSV2.healee_TONV.outbit "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD00005FC /end MEASUREMENT
/begin MEASUREMENT DHELSV2.healee_TONV.time "" UBYTE t_q0p05 1 100 0.00 12.75 FORMAT "%5.2" ECU_ADDRESS 0xD00005FD /end MEASUREMENT
/begin MEASUREMENT DHELSV2.heater_on_FF.status "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD00005FE /end MEASUREMENT
/begin MEASUREMENT DHELSV2.max_TONV.outbit "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD0000600 /end MEASUREMENT
/begin MEASUREMENT DHELSV2.max_TONV.time "" UBYTE t_q0p05 1 100 0.00 12.75 FORMAT "%5.2" ECU_ADDRESS 0xD0000601 /end MEASUREMENT
/begin MEASUREMENT DHELSV2.min_TONV.outbit "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD0000602 /end MEASUREMENT
/begin MEASUREMENT DHELSV2.min_TONV.time "" UBYTE t_q0p05 1 100 0.00 12.75 FORMAT "%5.2" ECU_ADDRESS 0xD0000603 /end MEASUREMENT
/begin MEASUREMENT DHELSV2.sig_TONV.outbit "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD0000604 /end MEASUREMENT
/begin MEASUREMENT DHELSV2.sig_TONV.time "" UBYTE t_q0p05 1 100 0.00 12.75 FORMAT "%5.2" ECU_ADDRESS 0xD0000605 /end MEASUREMENT
/begin MEASUREMENT DHELSV2.tvmn_TONV.outbit "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD0000606 /end MEASUREMENT
/begin MEASUREMENT DHELSV2.tvmn_TONV.time "" UBYTE t_q0p01 1 100 0.00 2.550 FORMAT "%5.3" ECU_ADDRESS 0xD0000607 /end MEASUREMENT
/begin MEASUREMENT DHELSV2.tvmx_TONV.outbit "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD0000608 /end MEASUREMENT
/begin MEASUREMENT DHELSV2.tvmx_TONV.time "" UBYTE t_q0p01 1 100 0.00 2.550 FORMAT "%5.3" ECU_ADDRESS 0xD0000609 /end MEASUREMENT
/begin MEASUREMENT DHELSV2.tvsi_TONV.outbit "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD000060A /end MEASUREMENT
/begin MEASUREMENT DHELSV2.tvsi_TONV.time "" UBYTE t_q0p01 1 100 0.00 2.550 FORMAT "%5.3" ECU_ADDRESS 0xD000060B /end MEASUREMENT
/begin MEASUREMENT DICLSU_B_ekusvk2_TONV.outbit "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD0000620 /end MEASUREMENT
/begin MEASUREMENT DICLSU_B_ekusvk2_TONV.time "" UBYTE t_q0p1 1 100 0.00 25.50 FORMAT "%5.2" ECU_ADDRESS 0xD0000621 /end MEASUREMENT
/begin MEASUREMENT DICLSU_B_ekusvk_TONV.outbit "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD0000622 /end MEASUREMENT
/begin MEASUREMENT DICLSU_B_ekusvk_TONV.time "" UBYTE t_q0p1 1 100 0.00 25.50 FORMAT "%5.2" ECU_ADDRESS 0xD0000623 /end MEASUREMENT
/begin MEASUREMENT DICLSU_B_sa_TONV.outbit "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD0000624 /end MEASUREMENT
/begin MEASUREMENT DICLSU_B_sa_TONV.time "" UBYTE t_q0p1 1 100 0.00 25.50 FORMAT "%5.2" ECU_ADDRESS 0xD0000625 /end MEASUREMENT
/begin MEASUREMENT DICLSU_ocvmhl2_TONV.outbit "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD0000626 /end MEASUREMENT
/begin MEASUREMENT DICLSU_ocvmhl2_TONV.time "" UBYTE t_q0p1 1 100 0.00 25.50 FORMAT "%5.2" ECU_ADDRESS 0xD0000627 /end MEASUREMENT
/begin MEASUREMENT DICLSU_ocvmhl_TONV.outbit "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD0000628 /end MEASUREMENT
/begin MEASUREMENT DICLSU_ocvmhl_TONV.time "" UBYTE t_q0p1 1 100 0.00 25.50 FORMAT "%5.2" ECU_ADDRESS 0xD0000629 /end MEASUREMENT
/begin MEASUREMENT DINH_ctMonCorr "" UWORD OneToOne 1 100 0.00 65535.00 FORMAT "%8.2" ECU_ADDRESS 0xD0016B30 /end MEASUREMENT
/begin MEASUREMENT DINH_stClctFId_mp "" UWORD DFC_OneToOne 1 100 0.00 65535.00 FORMAT "%8.2" ARRAY_SIZE 4 ECU_ADDRESS 0xD0017AFE /end MEASUREMENT
/begin MEASUREMENT DINH_stFId.FId_Unused "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0016DB5 /end MEASUREMENT
/begin MEASUREMENT DINH_stFId.FId_InhibitAlways "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0016DB6 /end MEASUREMENT
/begin MEASUREMENT DINH_stFId.FId_CoordTDCAdap "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0016DB7 /end MEASUREMENT
/begin MEASUREMENT DINH_stFId.FID_CIA "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0016DB8 /end MEASUREMENT
/begin MEASUREMENT DINH_stFId.FID_CIA2 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0016DB9 /end MEASUREMENT
/begin MEASUREMENT DINH_stFId.FID_CIP "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0016DBA /end MEASUREMENT
/begin MEASUREMENT DINH_stFId.FID_CIP2 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0016DBB /end MEASUREMENT
/begin MEASUREMENT DINH_stFId.FID_CLSFE "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0016DBC /end MEASUREMENT
/begin MEASUREMENT DINH_stFId.FID_CLSFE2 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0016DBD /end MEASUREMENT
/begin MEASUREMENT DINH_stFId.FID_CLSHE "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0016DBE /end MEASUREMENT
/begin MEASUREMENT DINH_stFId.FID_CLSHE2 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0016DBF /end MEASUREMENT
/begin MEASUREMENT DINH_stFId.FID_CLSVE "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0016DC0 /end MEASUREMENT
/begin MEASUREMENT DINH_stFId.FID_CLSVE2 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0016DC1 /end MEASUREMENT
/begin MEASUREMENT DINH_stFId.FId_BusDiagBusOffRxNodeA "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0016DC2 /end MEASUREMENT
/begin MEASUREMENT DINH_stFId.FId_BusDiagBusOffRxNodeB "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0016DC3 /end MEASUREMENT
/begin MEASUREMENT DINH_stFId.FId_BusDiagBusOffRxNodeC "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0016DC4 /end MEASUREMENT
/begin MEASUREMENT DINH_stFId.FId_BusDiagBusOffRxNodeD "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0016DC5 /end MEASUREMENT
/begin MEASUREMENT DINH_stFId.FId_BusDiagBusOffTxNodeA "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0016DC6 /end MEASUREMENT
/begin MEASUREMENT DINH_stFId.FId_BusDiagBusOffTxNodeB "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0016DC7 /end MEASUREMENT
/begin MEASUREMENT DINH_stFId.FId_BusDiagBusOffTxNodeC "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0016DC8 /end MEASUREMENT
/begin MEASUREMENT DINH_stFId.FId_BusDiagBusOffTxNodeD "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0016DC9 /end MEASUREMENT
/begin MEASUREMENT DINH_stFId.FId_Cic751Dev1 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0016DCA /end MEASUREMENT
/begin MEASUREMENT DINH_stFId.FId_ComEngSpd "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0016DCB /end MEASUREMENT
/begin MEASUREMENT DINH_stFId.FId_DSMWarmUpCycle "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0016DCC /end MEASUREMENT
/begin MEASUREMENT DINH_stFId.FId_EpmCaSAdapCaSI1 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0016DCD /end MEASUREMENT
/begin MEASUREMENT DINH_stFId.FId_EpmCaSAdapCaSI2 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0016DCE /end MEASUREMENT
/begin MEASUREMENT DINH_stFId.FId_EpmCaSAdapCaSO1 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0016DCF /end MEASUREMENT
/begin MEASUREMENT DINH_stFId.FId_EpmCaSAdapCaSO2 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0016DD0 /end MEASUREMENT
/begin MEASUREMENT DINH_stFId.FId_EpmCaSDiagI1 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0016DD1 /end MEASUREMENT
/begin MEASUREMENT DINH_stFId.FId_EpmCaSDiagI2 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0016DD2 /end MEASUREMENT
/begin MEASUREMENT DINH_stFId.FId_EpmCaSDiagO1 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0016DD3 /end MEASUREMENT
/begin MEASUREMENT DINH_stFId.FId_EpmCaSDiagO2 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0016DD4 /end MEASUREMENT
/begin MEASUREMENT DINH_stFId.FId_EpmCaSErrCaSI1 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0016DD5 /end MEASUREMENT
/begin MEASUREMENT DINH_stFId.FId_EpmCaSErrCaSI2 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0016DD6 /end MEASUREMENT
/begin MEASUREMENT DINH_stFId.FId_EpmCaSErrCaSO1 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0016DD7 /end MEASUREMENT
/begin MEASUREMENT DINH_stFId.FId_EpmCaSErrCaSO2 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0016DD8 /end MEASUREMENT
/begin MEASUREMENT DINH_stFId.FId_EpmCaSOfsDiagCaSI1 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0016DD9 /end MEASUREMENT
/begin MEASUREMENT DINH_stFId.FId_EpmCaSOfsDiagCaSI2 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0016DDA /end MEASUREMENT
/begin MEASUREMENT DINH_stFId.FId_EpmCaSOfsDiagCaSO1 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0016DDB /end MEASUREMENT
/begin MEASUREMENT DINH_stFId.FId_EpmCaSOfsDiagCaSO2 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0016DDC /end MEASUREMENT
/begin MEASUREMENT DINH_stFId.FId_EpmCaSOfsErrCaSI1 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0016DDD /end MEASUREMENT
/begin MEASUREMENT DINH_stFId.FId_EpmCaSOfsErrCaSI2 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0016DDE /end MEASUREMENT
/begin MEASUREMENT DINH_stFId.FId_EpmCaSOfsErrCaSO1 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0016DDF /end MEASUREMENT
/begin MEASUREMENT DINH_stFId.FId_EpmCaSOfsErrCaSO2 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0016DE0 /end MEASUREMENT
/begin MEASUREMENT DINH_stFId.FId_EpmCaSSegI1 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0016DE1 /end MEASUREMENT
/begin MEASUREMENT DINH_stFId.FId_EpmCaSSegI2 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0016DE2 /end MEASUREMENT
/begin MEASUREMENT DINH_stFId.FId_EpmCaSSegO1 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0016DE3 /end MEASUREMENT
/begin MEASUREMENT DINH_stFId.FId_EpmCaSSegO2 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0016DE4 /end MEASUREMENT
/begin MEASUREMENT DINH_stFId.FId_EpmCrSDiag "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0016DE5 /end MEASUREMENT
/begin MEASUREMENT DINH_stFId.FId_EpmCrSDiagVeh "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0016DE6 /end MEASUREMENT
/begin MEASUREMENT DINH_stFId.FId_EpmCrSErr "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0016DE7 /end MEASUREMENT
/begin MEASUREMENT DINH_stFId.FId_EpmOpMode_InjLock "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0016DE8 /end MEASUREMENT
/begin MEASUREMENT DINH_stFId.FId_InhibitNever "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0016DE9 /end MEASUREMENT
/begin MEASUREMENT DINH_stFId.FId_KnDetSens1 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0016DEA /end MEASUREMENT
/begin MEASUREMENT DINH_stFId.FId_KnDetSens2 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0016DEB /end MEASUREMENT
/begin MEASUREMENT DINH_stFId.FId_KnDetSens3 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0016DEC /end MEASUREMENT
/begin MEASUREMENT DINH_stFId.FId_KnDetSens4 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0016DED /end MEASUREMENT
/begin MEASUREMENT DINH_stFId.FId_MRlyStk "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0016DEE /end MEASUREMENT
/begin MEASUREMENT DINH_stFId.FId_MSVE "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0016DEF /end MEASUREMENT
/begin MEASUREMENT DINH_stFId.FId_MSVE2 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0016DF0 /end MEASUREMENT
/begin MEASUREMENT DINH_stFId.FId_TDCAdap "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0016DF1 /end MEASUREMENT
/begin MEASUREMENT DINH_xFIDObsvInh_mp "" UWORD DFCDSQ_Verb 1 100 0.00 427. FORMAT "%2.0" ARRAY_SIZE 1 ECU_ADDRESS 0xD0017B06 /end MEASUREMENT
/begin MEASUREMENT DINH_xFIDObsvRls_mp "" UWORD DFCDSQ_Verb 1 100 0.00 427. FORMAT "%2.0" ARRAY_SIZE 1 ECU_ADDRESS 0xD0017B08 /end MEASUREMENT
/begin MEASUREMENT dkrksanf "" UBYTE dez 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0001858 /end MEASUREMENT
/begin MEASUREMENT DLSZPF.B_anzhzk "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD00006FC /end MEASUREMENT
/begin MEASUREMENT DLSZPF.B_anzhzo "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x2 FORMAT "%13.11" ECU_ADDRESS 0xD00006FC /end MEASUREMENT
/begin MEASUREMENT DLSZPF.B_hzkf "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD00006F8 /end MEASUREMENT
/begin MEASUREMENT DLSZPF.B_hzkzyk "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD00006F9 /end MEASUREMENT
/begin MEASUREMENT DLSZPF.B_risig "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x10 FORMAT "%13.11" ECU_ADDRESS 0xD00006FB /end MEASUREMENT
/begin MEASUREMENT DLSZPF.B_sigfls "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x20 FORMAT "%13.11" ECU_ADDRESS 0xD00006FB /end MEASUREMENT
/begin MEASUREMENT DLSZPF.B_tushzf "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x4 FORMAT "%13.11" ECU_ADDRESS 0xD00006FC /end MEASUREMENT
/begin MEASUREMENT DLSZPF.B_usminf "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x2 FORMAT "%13.11" ECU_ADDRESS 0xD00006FB /end MEASUREMENT
/begin MEASUREMENT DLSZPF.B_usminfp "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD00006FA /end MEASUREMENT
/begin MEASUREMENT DLSZPF.usftsa "" UWORD spg_uw_q0p00488_o1 1 100 -1.000000 318.9951 FORMAT "%8.4" ECU_ADDRESS 0xD001ABB6 /end MEASUREMENT
/begin MEASUREMENT DLSZPF.uslpmn_w "" UWORD spg_q0p00488 1 100 0.00 319.9951 FORMAT "%8.4" ECU_ADDRESS 0xD001ABB8 /end MEASUREMENT
/begin MEASUREMENT DLSZPF.uslpmx_w "" UWORD spg_q0p00488 1 100 0.00 319.9951 FORMAT "%8.4" ECU_ADDRESS 0xD001ABBA /end MEASUREMENT
/begin MEASUREMENT DLSZPF.usmgsa "" UWORD spg_uw_q0p00488_o1 1 100 -1.000000 318.9951 FORMAT "%8.4" ECU_ADDRESS 0xD001ABBC /end MEASUREMENT
/begin MEASUREMENT DLSZPF.usslz_w "" UWORD spg_uw_q0p00488_o1 1 100 -1.000000 318.9951 FORMAT "%8.4" ECU_ADDRESS 0xD001ABBE /end MEASUREMENT
/begin MEASUREMENT DLSZPF.zhzk "" UBYTE dez 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0000700 /end MEASUREMENT
/begin MEASUREMENT DLSZPF.zhzoffh "" UBYTE dez 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0000701 /end MEASUREMENT
/begin MEASUREMENT DLSZPF.DLSMIN_ZA.B_usminfp "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD0000708 /end MEASUREMENT
/begin MEASUREMENT DLSZPF.DLSMIN_ZA.B_usmn3p "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD0000709 /end MEASUREMENT
/begin MEASUREMENT DLSZPF.DLSMIN_ZA.sm "" UBYTE OneToOne 1 100 0.00 3.000 FORMAT "%5.3" ECU_ADDRESS 0xD000070A /end MEASUREMENT
/begin MEASUREMENT DLSZPF.DLSSIG_ZA.B_us1lp "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD000070F /end MEASUREMENT
/begin MEASUREMENT DLSZPF.DLSSIG_ZA.B_us3lp "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x2 FORMAT "%13.11" ECU_ADDRESS 0xD000070F /end MEASUREMENT
/begin MEASUREMENT DLSZPF.DLSSIG_ZA.B_ussg1p "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD000070C /end MEASUREMENT
/begin MEASUREMENT DLSZPF.DLSSIG_ZA.B_ussg3p "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD000070D /end MEASUREMENT
/begin MEASUREMENT DLSZPF.DLSSIG_ZA.B_ussigfp "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD000070E /end MEASUREMENT
/begin MEASUREMENT DLSZPF.DLSSIG_ZA.B_ussiglp "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x4 FORMAT "%13.11" ECU_ADDRESS 0xD000070F /end MEASUREMENT
/begin MEASUREMENT DLSZPF.DLSSIG_ZA.sm "" UBYTE OneToOne 1 100 0.00 4.000 FORMAT "%5.3" ECU_ADDRESS 0xD0000710 /end MEASUREMENT
/begin MEASUREMENT DLSZPF2.B_anzhzk "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD000072C /end MEASUREMENT
/begin MEASUREMENT DLSZPF2.B_anzhzo "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x2 FORMAT "%13.11" ECU_ADDRESS 0xD000072C /end MEASUREMENT
/begin MEASUREMENT DLSZPF2.B_hzkf "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD0000728 /end MEASUREMENT
/begin MEASUREMENT DLSZPF2.B_hzkzyk "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD0000729 /end MEASUREMENT
/begin MEASUREMENT DLSZPF2.B_risig "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x10 FORMAT "%13.11" ECU_ADDRESS 0xD000072B /end MEASUREMENT
/begin MEASUREMENT DLSZPF2.B_sigfls "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x20 FORMAT "%13.11" ECU_ADDRESS 0xD000072B /end MEASUREMENT
/begin MEASUREMENT DLSZPF2.B_tushzf "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x4 FORMAT "%13.11" ECU_ADDRESS 0xD000072C /end MEASUREMENT
/begin MEASUREMENT DLSZPF2.B_usminf "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x2 FORMAT "%13.11" ECU_ADDRESS 0xD000072B /end MEASUREMENT
/begin MEASUREMENT DLSZPF2.B_usminfp "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD000072A /end MEASUREMENT
/begin MEASUREMENT DLSZPF2.usftsa "" UWORD spg_uw_q0p00488_o1 1 100 -1.000000 318.9951 FORMAT "%8.4" ECU_ADDRESS 0xD001ABC0 /end MEASUREMENT
/begin MEASUREMENT DLSZPF2.uslpmn_w "" UWORD spg_q0p00488 1 100 0.00 319.9951 FORMAT "%8.4" ECU_ADDRESS 0xD001ABC2 /end MEASUREMENT
/begin MEASUREMENT DLSZPF2.uslpmx_w "" UWORD spg_q0p00488 1 100 0.00 319.9951 FORMAT "%8.4" ECU_ADDRESS 0xD001ABC4 /end MEASUREMENT
/begin MEASUREMENT DLSZPF2.usmgsa "" UWORD spg_uw_q0p00488_o1 1 100 -1.000000 318.9951 FORMAT "%8.4" ECU_ADDRESS 0xD001ABC6 /end MEASUREMENT
/begin MEASUREMENT DLSZPF2.usslz_w "" UWORD spg_uw_q0p00488_o1 1 100 -1.000000 318.9951 FORMAT "%8.4" ECU_ADDRESS 0xD001ABC8 /end MEASUREMENT
/begin MEASUREMENT DLSZPF2.zhzk "" UBYTE dez 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0000730 /end MEASUREMENT
/begin MEASUREMENT DLSZPF2.zhzoffh "" UBYTE dez 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0000731 /end MEASUREMENT
/begin MEASUREMENT DLSZPF2.DLSMIN_ZA.B_usminfp "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD0000738 /end MEASUREMENT
/begin MEASUREMENT DLSZPF2.DLSMIN_ZA.B_usmn3p "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD0000739 /end MEASUREMENT
/begin MEASUREMENT DLSZPF2.DLSMIN_ZA.sm "" UBYTE OneToOne 1 100 0.00 3.000 FORMAT "%5.3" ECU_ADDRESS 0xD000073A /end MEASUREMENT
/begin MEASUREMENT DLSZPF2.DLSSIG_ZA.B_us1lp "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD000073F /end MEASUREMENT
/begin MEASUREMENT DLSZPF2.DLSSIG_ZA.B_us3lp "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x2 FORMAT "%13.11" ECU_ADDRESS 0xD000073F /end MEASUREMENT
/begin MEASUREMENT DLSZPF2.DLSSIG_ZA.B_ussg1p "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD000073C /end MEASUREMENT
/begin MEASUREMENT DLSZPF2.DLSSIG_ZA.B_ussg3p "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD000073D /end MEASUREMENT
/begin MEASUREMENT DLSZPF2.DLSSIG_ZA.B_ussigfp "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD000073E /end MEASUREMENT
/begin MEASUREMENT DLSZPF2.DLSSIG_ZA.B_ussiglp "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x4 FORMAT "%13.11" ECU_ADDRESS 0xD000073F /end MEASUREMENT
/begin MEASUREMENT DLSZPF2.DLSSIG_ZA.sm "" UBYTE OneToOne 1 100 0.00 4.000 FORMAT "%5.3" ECU_ADDRESS 0xD0000740 /end MEASUREMENT
/begin MEASUREMENT DLSZPH.B_anzhzk "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD000075C /end MEASUREMENT
/begin MEASUREMENT DLSZPH.B_anzhzo "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x2 FORMAT "%13.11" ECU_ADDRESS 0xD000075C /end MEASUREMENT
/begin MEASUREMENT DLSZPH.B_hzkf "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD0000758 /end MEASUREMENT
/begin MEASUREMENT DLSZPH.B_hzkzyk "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD0000759 /end MEASUREMENT
/begin MEASUREMENT DLSZPH.B_risig "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x10 FORMAT "%13.11" ECU_ADDRESS 0xD000075B /end MEASUREMENT
/begin MEASUREMENT DLSZPH.B_sigfls "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x20 FORMAT "%13.11" ECU_ADDRESS 0xD000075B /end MEASUREMENT
/begin MEASUREMENT DLSZPH.B_tushzf "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x4 FORMAT "%13.11" ECU_ADDRESS 0xD000075C /end MEASUREMENT
/begin MEASUREMENT DLSZPH.B_usminf "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x2 FORMAT "%13.11" ECU_ADDRESS 0xD000075B /end MEASUREMENT
/begin MEASUREMENT DLSZPH.B_usminfp "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD000075A /end MEASUREMENT
/begin MEASUREMENT DLSZPH.usftsa "" UWORD spg_uw_q0p00488_o1 1 100 -1.000000 318.9951 FORMAT "%8.4" ECU_ADDRESS 0xD001ABCA /end MEASUREMENT
/begin MEASUREMENT DLSZPH.uslpmn_w "" UWORD spg_q0p00488 1 100 0.00 319.9951 FORMAT "%8.4" ECU_ADDRESS 0xD001ABCC /end MEASUREMENT
/begin MEASUREMENT DLSZPH.uslpmx_w "" UWORD spg_q0p00488 1 100 0.00 319.9951 FORMAT "%8.4" ECU_ADDRESS 0xD001ABCE /end MEASUREMENT
/begin MEASUREMENT DLSZPH.usmgsa "" UWORD spg_uw_q0p00488_o1 1 100 -1.000000 318.9951 FORMAT "%8.4" ECU_ADDRESS 0xD001ABD0 /end MEASUREMENT
/begin MEASUREMENT DLSZPH.usslz_w "" UWORD spg_uw_q0p00488_o1 1 100 -1.000000 318.9951 FORMAT "%8.4" ECU_ADDRESS 0xD001ABD2 /end MEASUREMENT
/begin MEASUREMENT DLSZPH.zhzk "" UBYTE dez 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0000760 /end MEASUREMENT
/begin MEASUREMENT DLSZPH.zhzoffh "" UBYTE dez 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0000761 /end MEASUREMENT
/begin MEASUREMENT DLSZPH.DLSMIN_ZA.B_usminfp "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD0000768 /end MEASUREMENT
/begin MEASUREMENT DLSZPH.DLSMIN_ZA.B_usmn3p "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD0000769 /end MEASUREMENT
/begin MEASUREMENT DLSZPH.DLSMIN_ZA.sm "" UBYTE OneToOne 1 100 0.00 3.000 FORMAT "%5.3" ECU_ADDRESS 0xD000076A /end MEASUREMENT
/begin MEASUREMENT DLSZPH.DLSSIG_ZA.B_us1lp "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD000076F /end MEASUREMENT
/begin MEASUREMENT DLSZPH.DLSSIG_ZA.B_us3lp "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x2 FORMAT "%13.11" ECU_ADDRESS 0xD000076F /end MEASUREMENT
/begin MEASUREMENT DLSZPH.DLSSIG_ZA.B_ussg1p "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD000076C /end MEASUREMENT
/begin MEASUREMENT DLSZPH.DLSSIG_ZA.B_ussg3p "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD000076D /end MEASUREMENT
/begin MEASUREMENT DLSZPH.DLSSIG_ZA.B_ussigfp "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD000076E /end MEASUREMENT
/begin MEASUREMENT DLSZPH.DLSSIG_ZA.B_ussiglp "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x4 FORMAT "%13.11" ECU_ADDRESS 0xD000076F /end MEASUREMENT
/begin MEASUREMENT DLSZPH.DLSSIG_ZA.sm "" UBYTE OneToOne 1 100 0.00 4.000 FORMAT "%5.3" ECU_ADDRESS 0xD0000770 /end MEASUREMENT
/begin MEASUREMENT DLSZPH2.B_anzhzk "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD000078C /end MEASUREMENT
/begin MEASUREMENT DLSZPH2.B_anzhzo "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x2 FORMAT "%13.11" ECU_ADDRESS 0xD000078C /end MEASUREMENT
/begin MEASUREMENT DLSZPH2.B_hzkf "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD0000788 /end MEASUREMENT
/begin MEASUREMENT DLSZPH2.B_hzkzyk "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD0000789 /end MEASUREMENT
/begin MEASUREMENT DLSZPH2.B_risig "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x10 FORMAT "%13.11" ECU_ADDRESS 0xD000078B /end MEASUREMENT
/begin MEASUREMENT DLSZPH2.B_sigfls "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x20 FORMAT "%13.11" ECU_ADDRESS 0xD000078B /end MEASUREMENT
/begin MEASUREMENT DLSZPH2.B_tushzf "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x4 FORMAT "%13.11" ECU_ADDRESS 0xD000078C /end MEASUREMENT
/begin MEASUREMENT DLSZPH2.B_usminf "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x2 FORMAT "%13.11" ECU_ADDRESS 0xD000078B /end MEASUREMENT
/begin MEASUREMENT DLSZPH2.B_usminfp "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD000078A /end MEASUREMENT
/begin MEASUREMENT DLSZPH2.usftsa "" UWORD spg_uw_q0p00488_o1 1 100 -1.000000 318.9951 FORMAT "%8.4" ECU_ADDRESS 0xD001ABD4 /end MEASUREMENT
/begin MEASUREMENT DLSZPH2.uslpmn_w "" UWORD spg_q0p00488 1 100 0.00 319.9951 FORMAT "%8.4" ECU_ADDRESS 0xD001ABD6 /end MEASUREMENT
/begin MEASUREMENT DLSZPH2.uslpmx_w "" UWORD spg_q0p00488 1 100 0.00 319.9951 FORMAT "%8.4" ECU_ADDRESS 0xD001ABD8 /end MEASUREMENT
/begin MEASUREMENT DLSZPH2.usmgsa "" UWORD spg_uw_q0p00488_o1 1 100 -1.000000 318.9951 FORMAT "%8.4" ECU_ADDRESS 0xD001ABDA /end MEASUREMENT
/begin MEASUREMENT DLSZPH2.usslz_w "" UWORD spg_uw_q0p00488_o1 1 100 -1.000000 318.9951 FORMAT "%8.4" ECU_ADDRESS 0xD001ABDC /end MEASUREMENT
/begin MEASUREMENT DLSZPH2.zhzk "" UBYTE dez 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0000790 /end MEASUREMENT
/begin MEASUREMENT DLSZPH2.zhzoffh "" UBYTE dez 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0000791 /end MEASUREMENT
/begin MEASUREMENT DLSZPH2.DLSMIN_ZA.B_usminfp "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD0000798 /end MEASUREMENT
/begin MEASUREMENT DLSZPH2.DLSMIN_ZA.B_usmn3p "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD0000799 /end MEASUREMENT
/begin MEASUREMENT DLSZPH2.DLSMIN_ZA.sm "" UBYTE OneToOne 1 100 0.00 3.000 FORMAT "%5.3" ECU_ADDRESS 0xD000079A /end MEASUREMENT
/begin MEASUREMENT DLSZPH2.DLSSIG_ZA.B_us1lp "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD000079F /end MEASUREMENT
/begin MEASUREMENT DLSZPH2.DLSSIG_ZA.B_us3lp "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x2 FORMAT "%13.11" ECU_ADDRESS 0xD000079F /end MEASUREMENT
/begin MEASUREMENT DLSZPH2.DLSSIG_ZA.B_ussg1p "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD000079C /end MEASUREMENT
/begin MEASUREMENT DLSZPH2.DLSSIG_ZA.B_ussg3p "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD000079D /end MEASUREMENT
/begin MEASUREMENT DLSZPH2.DLSSIG_ZA.B_ussigfp "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD000079E /end MEASUREMENT
/begin MEASUREMENT DLSZPH2.DLSSIG_ZA.B_ussiglp "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x4 FORMAT "%13.11" ECU_ADDRESS 0xD000079F /end MEASUREMENT
/begin MEASUREMENT DLSZPH2.DLSSIG_ZA.sm "" UBYTE OneToOne 1 100 0.00 4.000 FORMAT "%5.3" ECU_ADDRESS 0xD00007A0 /end MEASUREMENT
/begin MEASUREMENT DLSZPV.B_csd "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD001ABDE /end MEASUREMENT
/begin MEASUREMENT DLSZPV.B_dmaso "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD00007BA /end MEASUREMENT
/begin MEASUREMENT DLSZPV.B_hzkf "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD00007B8 /end MEASUREMENT
/begin MEASUREMENT DLSZPV.B_lrspras "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x2 FORMAT "%13.11" ECU_ADDRESS 0xD00007BA /end MEASUREMENT
/begin MEASUREMENT DLSZPV.B_maso "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x2 FORMAT "%13.11" ECU_ADDRESS 0xD001ABDE /end MEASUREMENT
/begin MEASUREMENT DLSZPV.B_refmax "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x4 FORMAT "%13.11" ECU_ADDRESS 0xD00007BA /end MEASUREMENT
/begin MEASUREMENT DLSZPV.B_stkcvb "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x10 FORMAT "%13.11" ECU_ADDRESS 0xD00007BA /end MEASUREMENT
/begin MEASUREMENT DLSZPV.B_stkhigh "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x4 FORMAT "%13.11" ECU_ADDRESS 0xD001ABDE /end MEASUREMENT
/begin MEASUREMENT DLSZPV.B_stklow "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x8 FORMAT "%13.11" ECU_ADDRESS 0xD001ABDE /end MEASUREMENT
/begin MEASUREMENT DLSZPV.B_usfhk "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x8 FORMAT "%13.11" ECU_ADDRESS 0xD00007BA /end MEASUREMENT
/begin MEASUREMENT DLSZPV.B_usrich "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD00007B9 /end MEASUREMENT
/begin MEASUREMENT DLSZPV.B_usstkcvb "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x20 FORMAT "%13.11" ECU_ADDRESS 0xD00007BA /end MEASUREMENT
/begin MEASUREMENT DLSZPV.msoxy_w "" UWORD m_q0p0peri4 1 100 0.00 2912.667 FORMAT "%8.3" ECU_ADDRESS 0xD00007BC /end MEASUREMENT
/begin MEASUREMENT DLSZPV.DLSV.B_anzhzk "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD00007C2 /end MEASUREMENT
/begin MEASUREMENT DLSZPV.DLSV.B_anzhzo "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x2 FORMAT "%13.11" ECU_ADDRESS 0xD00007C2 /end MEASUREMENT
/begin MEASUREMENT DLSZPV.DLSV.B_hzkf "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD00007BE /end MEASUREMENT
/begin MEASUREMENT DLSZPV.DLSV.B_hzkzyk "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD00007BF /end MEASUREMENT
/begin MEASUREMENT DLSZPV.DLSV.B_risig "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x10 FORMAT "%13.11" ECU_ADDRESS 0xD00007C1 /end MEASUREMENT
/begin MEASUREMENT DLSZPV.DLSV.B_sigfls "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x20 FORMAT "%13.11" ECU_ADDRESS 0xD00007C1 /end MEASUREMENT
/begin MEASUREMENT DLSZPV.DLSV.B_tushzf "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x4 FORMAT "%13.11" ECU_ADDRESS 0xD00007C2 /end MEASUREMENT
/begin MEASUREMENT DLSZPV.DLSV.B_usminf "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x2 FORMAT "%13.11" ECU_ADDRESS 0xD00007C1 /end MEASUREMENT
/begin MEASUREMENT DLSZPV.DLSV.B_usminfp "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD00007C0 /end MEASUREMENT
/begin MEASUREMENT DLSZPV.DLSV.usftsa "" UWORD spg_uw_q0p00488_o1 1 100 -1.000000 318.9951 FORMAT "%8.4" ECU_ADDRESS 0xD001ABE0 /end MEASUREMENT
/begin MEASUREMENT DLSZPV.DLSV.uslpmn_w "" UWORD spg_q0p00488 1 100 0.00 319.9951 FORMAT "%8.4" ECU_ADDRESS 0xD001ABE2 /end MEASUREMENT
/begin MEASUREMENT DLSZPV.DLSV.uslpmx_w "" UWORD spg_q0p00488 1 100 0.00 319.9951 FORMAT "%8.4" ECU_ADDRESS 0xD001ABE4 /end MEASUREMENT
/begin MEASUREMENT DLSZPV.DLSV.usmgsa "" UWORD spg_uw_q0p00488_o1 1 100 -1.000000 318.9951 FORMAT "%8.4" ECU_ADDRESS 0xD001ABE6 /end MEASUREMENT
/begin MEASUREMENT DLSZPV.DLSV.usslz_w "" UWORD spg_uw_q0p00488_o1 1 100 -1.000000 318.9951 FORMAT "%8.4" ECU_ADDRESS 0xD001ABE8 /end MEASUREMENT
/begin MEASUREMENT DLSZPV.DLSV.zhzk "" UBYTE dez 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD00007C6 /end MEASUREMENT
/begin MEASUREMENT DLSZPV.DLSV.zhzoffh "" UBYTE dez 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD00007C7 /end MEASUREMENT
/begin MEASUREMENT DLSZPV.DLSV.DLSMIN_ZA.B_usminfp "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD00007CE /end MEASUREMENT
/begin MEASUREMENT DLSZPV.DLSV.DLSMIN_ZA.B_usmn3p "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD00007CF /end MEASUREMENT
/begin MEASUREMENT DLSZPV.DLSV.DLSMIN_ZA.sm "" UBYTE OneToOne 1 100 0.00 3.000 FORMAT "%5.3" ECU_ADDRESS 0xD00007D0 /end MEASUREMENT
/begin MEASUREMENT DLSZPV.DLSV.DLSSIG_ZA.B_us1lp "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD00007D5 /end MEASUREMENT
/begin MEASUREMENT DLSZPV.DLSV.DLSSIG_ZA.B_us3lp "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x2 FORMAT "%13.11" ECU_ADDRESS 0xD00007D5 /end MEASUREMENT
/begin MEASUREMENT DLSZPV.DLSV.DLSSIG_ZA.B_ussg1p "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD00007D2 /end MEASUREMENT
/begin MEASUREMENT DLSZPV.DLSV.DLSSIG_ZA.B_ussg3p "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD00007D3 /end MEASUREMENT
/begin MEASUREMENT DLSZPV.DLSV.DLSSIG_ZA.B_ussigfp "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD00007D4 /end MEASUREMENT
/begin MEASUREMENT DLSZPV.DLSV.DLSSIG_ZA.B_ussiglp "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x4 FORMAT "%13.11" ECU_ADDRESS 0xD00007D5 /end MEASUREMENT
/begin MEASUREMENT DLSZPV.DLSV.DLSSIG_ZA.sm "" UBYTE OneToOne 1 100 0.00 4.000 FORMAT "%5.3" ECU_ADDRESS 0xD00007D6 /end MEASUREMENT
/begin MEASUREMENT DLSZPV2.B_csd "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD001ABEA /end MEASUREMENT
/begin MEASUREMENT DLSZPV2.B_dmaso "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD0000816 /end MEASUREMENT
/begin MEASUREMENT DLSZPV2.B_hzkf "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD0000814 /end MEASUREMENT
/begin MEASUREMENT DLSZPV2.B_lrspras "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x2 FORMAT "%13.11" ECU_ADDRESS 0xD0000816 /end MEASUREMENT
/begin MEASUREMENT DLSZPV2.B_maso "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x2 FORMAT "%13.11" ECU_ADDRESS 0xD001ABEA /end MEASUREMENT
/begin MEASUREMENT DLSZPV2.B_refmax "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x4 FORMAT "%13.11" ECU_ADDRESS 0xD0000816 /end MEASUREMENT
/begin MEASUREMENT DLSZPV2.B_stkcvb "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x10 FORMAT "%13.11" ECU_ADDRESS 0xD0000816 /end MEASUREMENT
/begin MEASUREMENT DLSZPV2.B_stkhigh "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x4 FORMAT "%13.11" ECU_ADDRESS 0xD001ABEA /end MEASUREMENT
/begin MEASUREMENT DLSZPV2.B_stklow "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x8 FORMAT "%13.11" ECU_ADDRESS 0xD001ABEA /end MEASUREMENT
/begin MEASUREMENT DLSZPV2.B_usfhk "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x8 FORMAT "%13.11" ECU_ADDRESS 0xD0000816 /end MEASUREMENT
/begin MEASUREMENT DLSZPV2.B_usrich "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD0000815 /end MEASUREMENT
/begin MEASUREMENT DLSZPV2.B_usstkcvb "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x20 FORMAT "%13.11" ECU_ADDRESS 0xD0000816 /end MEASUREMENT
/begin MEASUREMENT DLSZPV2.msoxy_w "" UWORD m_q0p0peri4 1 100 0.00 2912.667 FORMAT "%8.3" ECU_ADDRESS 0xD0000818 /end MEASUREMENT
/begin MEASUREMENT DLSZPV2.DLSV.B_anzhzk "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD000081E /end MEASUREMENT
/begin MEASUREMENT DLSZPV2.DLSV.B_anzhzo "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x2 FORMAT "%13.11" ECU_ADDRESS 0xD000081E /end MEASUREMENT
/begin MEASUREMENT DLSZPV2.DLSV.B_hzkf "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD000081A /end MEASUREMENT
/begin MEASUREMENT DLSZPV2.DLSV.B_hzkzyk "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD000081B /end MEASUREMENT
/begin MEASUREMENT DLSZPV2.DLSV.B_risig "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x10 FORMAT "%13.11" ECU_ADDRESS 0xD000081D /end MEASUREMENT
/begin MEASUREMENT DLSZPV2.DLSV.B_sigfls "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x20 FORMAT "%13.11" ECU_ADDRESS 0xD000081D /end MEASUREMENT
/begin MEASUREMENT DLSZPV2.DLSV.B_tushzf "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x4 FORMAT "%13.11" ECU_ADDRESS 0xD000081E /end MEASUREMENT
/begin MEASUREMENT DLSZPV2.DLSV.B_usminf "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x2 FORMAT "%13.11" ECU_ADDRESS 0xD000081D /end MEASUREMENT
/begin MEASUREMENT DLSZPV2.DLSV.B_usminfp "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD000081C /end MEASUREMENT
/begin MEASUREMENT DLSZPV2.DLSV.usftsa "" UWORD spg_uw_q0p00488_o1 1 100 -1.000000 318.9951 FORMAT "%8.4" ECU_ADDRESS 0xD001ABEC /end MEASUREMENT
/begin MEASUREMENT DLSZPV2.DLSV.uslpmn_w "" UWORD spg_q0p00488 1 100 0.00 319.9951 FORMAT "%8.4" ECU_ADDRESS 0xD001ABEE /end MEASUREMENT
/begin MEASUREMENT DLSZPV2.DLSV.uslpmx_w "" UWORD spg_q0p00488 1 100 0.00 319.9951 FORMAT "%8.4" ECU_ADDRESS 0xD001ABF0 /end MEASUREMENT
/begin MEASUREMENT DLSZPV2.DLSV.usmgsa "" UWORD spg_uw_q0p00488_o1 1 100 -1.000000 318.9951 FORMAT "%8.4" ECU_ADDRESS 0xD001ABF2 /end MEASUREMENT
/begin MEASUREMENT DLSZPV2.DLSV.usslz_w "" UWORD spg_uw_q0p00488_o1 1 100 -1.000000 318.9951 FORMAT "%8.4" ECU_ADDRESS 0xD001ABF4 /end MEASUREMENT
/begin MEASUREMENT DLSZPV2.DLSV.zhzk "" UBYTE dez 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0000822 /end MEASUREMENT
/begin MEASUREMENT DLSZPV2.DLSV.zhzoffh "" UBYTE dez 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0000823 /end MEASUREMENT
/begin MEASUREMENT DLSZPV2.DLSV.DLSMIN_ZA.B_usminfp "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD000082A /end MEASUREMENT
/begin MEASUREMENT DLSZPV2.DLSV.DLSMIN_ZA.B_usmn3p "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD000082B /end MEASUREMENT
/begin MEASUREMENT DLSZPV2.DLSV.DLSMIN_ZA.sm "" UBYTE OneToOne 1 100 0.00 3.000 FORMAT "%5.3" ECU_ADDRESS 0xD000082C /end MEASUREMENT
/begin MEASUREMENT DLSZPV2.DLSV.DLSSIG_ZA.B_us1lp "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD0000831 /end MEASUREMENT
/begin MEASUREMENT DLSZPV2.DLSV.DLSSIG_ZA.B_us3lp "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x2 FORMAT "%13.11" ECU_ADDRESS 0xD0000831 /end MEASUREMENT
/begin MEASUREMENT DLSZPV2.DLSV.DLSSIG_ZA.B_ussg1p "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD000082E /end MEASUREMENT
/begin MEASUREMENT DLSZPV2.DLSV.DLSSIG_ZA.B_ussg3p "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD000082F /end MEASUREMENT
/begin MEASUREMENT DLSZPV2.DLSV.DLSSIG_ZA.B_ussigfp "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD0000830 /end MEASUREMENT
/begin MEASUREMENT DLSZPV2.DLSV.DLSSIG_ZA.B_ussiglp "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x4 FORMAT "%13.11" ECU_ADDRESS 0xD0000831 /end MEASUREMENT
/begin MEASUREMENT DLSZPV2.DLSV.DLSSIG_ZA.sm "" UBYTE OneToOne 1 100 0.00 4.000 FORMAT "%5.3" ECU_ADDRESS 0xD0000832 /end MEASUREMENT
/begin MEASUREMENT Dme_ctDataSetVariant "" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0017387 /end MEASUREMENT
/begin MEASUREMENT Dme_numBytesAvailable "" ULONG OneToOne 1 100 0.00 4294967295.00 FORMAT "%13.2" ECU_ADDRESS 0xD00153E0 /end MEASUREMENT
/begin MEASUREMENT Dme_numBytesAvailableOvl "" ULONG OneToOne 1 100 0.00 4294967295.00 FORMAT "%13.2" ECU_ADDRESS 0xD00153E4 /end MEASUREMENT
/begin MEASUREMENT dnmot_w "" SWORD nmot_sw_q0p25 1 100 -8192.000 8191.750 FORMAT "%8.3" ECU_ADDRESS 0xD0000D7C /end MEASUREMENT
/begin MEASUREMENT dps_error "" UWORD dez 1 100 0.00 65535.00 FORMAT "%8.2" ECU_ADDRESS 0xD0000D70 /end MEASUREMENT
/begin MEASUREMENT dps_errStat "" UWORD dez 1 100 0.00 65535.00 FORMAT "%8.2" ECU_ADDRESS 0xD0000D72 /end MEASUREMENT
/begin MEASUREMENT dps_errStat_sum_rec "" UWORD dez 1 100 0.00 65535.00 FORMAT "%8.2" ECU_ADDRESS 0xD0000D74 /end MEASUREMENT
/begin MEASUREMENT dps_errStat_sum_ver "" UWORD dez 1 100 0.00 65535.00 FORMAT "%8.2" ECU_ADDRESS 0xD0000D76 /end MEASUREMENT
/begin MEASUREMENT dps_index "" UBYTE dez 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0001739 /end MEASUREMENT
/begin MEASUREMENT dps_recoveryTime "" UBYTE t_q0p1 1 100 0.00 25.50 FORMAT "%5.2" ECU_ADDRESS 0xD000173A /end MEASUREMENT
/begin MEASUREMENT dps_state "" UBYTE dez 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD000173B /end MEASUREMENT
/begin MEASUREMENT dps_verifyTime "" UBYTE t_q0p1 1 100 0.00 25.50 FORMAT "%5.2" ECU_ADDRESS 0xD000173C /end MEASUREMENT
/begin MEASUREMENT DSCHED_DynPrio.FId_Unused "" SWORD DFC_OneToOne 1 100 -32768.00 32767.00 FORMAT "%8.2" ECU_ADDRESS 0xD001671C /end MEASUREMENT
/begin MEASUREMENT DSCHED_DynPrio.FId_InhibitAlways "" SWORD DFC_OneToOne 1 100 -32768.00 32767.00 FORMAT "%8.2" ECU_ADDRESS 0xD001671E /end MEASUREMENT
/begin MEASUREMENT DSCHED_DynPrio.FId_CoordTDCAdap "" SWORD DFC_OneToOne 1 100 -32768.00 32767.00 FORMAT "%8.2" ECU_ADDRESS 0xD0016720 /end MEASUREMENT
/begin MEASUREMENT DSCHED_PhysPrio.FId_Unused "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0016FE3 /end MEASUREMENT
/begin MEASUREMENT DSCHED_PhysPrio.FId_InhibitAlways "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0016FE4 /end MEASUREMENT
/begin MEASUREMENT DSCHED_PhysPrio.FId_CoordTDCAdap "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0016FE5 /end MEASUREMENT
/begin MEASUREMENT DSCHED_RmpPrio.FId_Unused "" UWORD DFC_OneToOne 1 100 0.00 65535.00 FORMAT "%8.2" ECU_ADDRESS 0xD001670A /end MEASUREMENT
/begin MEASUREMENT DSCHED_RmpPrio.FId_InhibitAlways "" UWORD DFC_OneToOne 1 100 0.00 65535.00 FORMAT "%8.2" ECU_ADDRESS 0xD001670C /end MEASUREMENT
/begin MEASUREMENT DSCHED_RmpPrio.FId_CoordTDCAdap "" UWORD DFC_OneToOne 1 100 0.00 65535.00 FORMAT "%8.2" ECU_ADDRESS 0xD001670E /end MEASUREMENT
/begin MEASUREMENT DSCHED_St.FId_Unused "" UBYTE DSCHED_StVerb 1 100 0.00 238.000000000 FORMAT "%13.9" ECU_ADDRESS 0xD0016FE0 /end MEASUREMENT
/begin MEASUREMENT DSCHED_St.FId_InhibitAlways "" UBYTE DSCHED_StVerb 1 100 0.00 238.000000000 FORMAT "%13.9" ECU_ADDRESS 0xD0016FE1 /end MEASUREMENT
/begin MEASUREMENT DSCHED_St.FId_CoordTDCAdap "" UBYTE DSCHED_StVerb 1 100 0.00 238.000000000 FORMAT "%13.9" ECU_ADDRESS 0xD0016FE2 /end MEASUREMENT
/begin MEASUREMENT DSCHED_TiActv.FId_Unused "" UWORD DFC_OneToOne 1 100 0.00 65535.00 FORMAT "%8.2" ECU_ADDRESS 0xD0016710 /end MEASUREMENT
/begin MEASUREMENT DSCHED_TiActv.FId_InhibitAlways "" UWORD DSCHED_Time200ms 1 100 0.00 13107.00 FORMAT "%8.2" ECU_ADDRESS 0xD0016712 /end MEASUREMENT
/begin MEASUREMENT DSCHED_TiActv.FId_CoordTDCAdap "" UWORD DSCHED_Time200ms 1 100 0.00 13107.00 FORMAT "%8.2" ECU_ADDRESS 0xD0016714 /end MEASUREMENT
/begin MEASUREMENT DSCHED_TiPas.FId_Unused "" UWORD DFC_OneToOne 1 100 0.00 65535.00 FORMAT "%8.2" ECU_ADDRESS 0xD0016716 /end MEASUREMENT
/begin MEASUREMENT DSCHED_TiPas.FId_InhibitAlways "" UWORD DSCHED_Time200ms 1 100 0.00 13107.00 FORMAT "%8.2" ECU_ADDRESS 0xD0016718 /end MEASUREMENT
/begin MEASUREMENT DSCHED_TiPas.FId_CoordTDCAdap "" UWORD DSCHED_Time200ms 1 100 0.00 13107.00 FORMAT "%8.2" ECU_ADDRESS 0xD001671A /end MEASUREMENT
/begin MEASUREMENT DSCHED_WhyExcl.FId_Unused "" UWORD DSCHED_FIdExcCauseVerb 1 100 0.00 255. FORMAT "%2.0" ECU_ADDRESS 0xD0016722 /end MEASUREMENT
/begin MEASUREMENT DSCHED_WhyExcl.FId_InhibitAlways "" UWORD DSCHED_FIdExcCauseVerb 1 100 0.00 255. FORMAT "%2.0" ECU_ADDRESS 0xD0016724 /end MEASUREMENT
/begin MEASUREMENT DSCHED_WhyExcl.FId_CoordTDCAdap "" UWORD DSCHED_FIdExcCauseVerb 1 100 0.00 255. FORMAT "%2.0" ECU_ADDRESS 0xD0016726 /end MEASUREMENT
/begin MEASUREMENT DSMAUX_ctWUC "" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001B038 /end MEASUREMENT
/begin MEASUREMENT DSMAUX_DTRG.DTRG_Time200ms "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0016FE6 /end MEASUREMENT
/begin MEASUREMENT DSMAUX_DTRG.DTRG_SimilarCondHLC "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0016FE7 /end MEASUREMENT
/begin MEASUREMENT DSMAUX_DTRG.DTRG_WarmUpCycle "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0016FE8 /end MEASUREMENT
/begin MEASUREMENT DSMAUX_DTRG.DTRG_DrivingCycleFLC "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0016FE9 /end MEASUREMENT
/begin MEASUREMENT DSMAUX_DTRG.DTRG_AlwaysTrue "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0016FEA /end MEASUREMENT
/begin MEASUREMENT DSMAUX_DTRG.DTRG_DrivingCycleHLC "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0016FEB /end MEASUREMENT
/begin MEASUREMENT DSMAUX_DTRG.bbsp2_17 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0016FEC /end MEASUREMENT
/begin MEASUREMENT DSMAUX_DTRG.bbsp1_17 "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0016FED /end MEASUREMENT
/begin MEASUREMENT DSMAUX_DTRG.DTRG_NoTrigger "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0016FEE /end MEASUREMENT
/begin MEASUREMENT DSMAUX_stStrtEnd "" UBYTE OneToOne 1 100 0.00 1.000 BIT_MASK 0x1 FORMAT "%5.3" ECU_ADDRESS 0xD0001928 /end MEASUREMENT
/begin MEASUREMENT DSMAUX_tClntStrt "" SWORD Temp_Cels 1 100 -3549.940 3003.560 FORMAT "%8.3" ECU_ADDRESS 0xD0016B44 /end MEASUREMENT
/begin MEASUREMENT DSMDur_ctGlb "" ULONG DFES_OneToOne 1 100 0.00 4294967295.00 FORMAT "%13.2" ARRAY_SIZE 1 ECU_ADDRESS 0xD001B03C /end MEASUREMENT
/begin MEASUREMENT DSMDur_ctPID21h "" ULONG DSMDUR_10m_Counter 1 100 0.00 42949672.9500 FORMAT "%13.4" ECU_ADDRESS 0xD001B044 /end MEASUREMENT
/begin MEASUREMENT DSMDur_ctPID31h "" ULONG DSMDUR_10m_Counter 1 100 0.00 42949672.9500 FORMAT "%13.4" ECU_ADDRESS 0xD001B048 /end MEASUREMENT
/begin MEASUREMENT DSMDur_stGlb "" UBYTE DSMDur_StDispl_Verb 1 100 0.00 2.00000000000 FORMAT "%13.11" ARRAY_SIZE 1 ECU_ADDRESS 0xD001B040 /end MEASUREMENT
/begin MEASUREMENT DSMDur_stPID21h "" UBYTE DSMDur_StDispl_Verb 1 100 0.00 2.00000000000 FORMAT "%13.11" ECU_ADDRESS 0xD001B04C /end MEASUREMENT
/begin MEASUREMENT DSMRdy_stGrpAct "" UWORD DSMRdy_OneToOne 1 100 0.00 65535.00 FORMAT "%8.2" ECU_ADDRESS 0xD001672E /end MEASUREMENT
/begin MEASUREMENT DSMRdy_stGrpLock "" UWORD DSMRdy_OneToOne 1 100 0.00 65535.00 FORMAT "%8.2" ECU_ADDRESS 0xD0016730 /end MEASUREMENT
/begin MEASUREMENT DSMRdy_stGrpRdy "" UWORD DSMRdy_OneToOne 1 100 0.00 65535.00 FORMAT "%8.2" ECU_ADDRESS 0xD001B054 /end MEASUREMENT
/begin MEASUREMENT DSMRdy_stGrpRdyDFES "" UWORD DSMRdy_OneToOne 1 100 0.00 65535.00 FORMAT "%8.2" ECU_ADDRESS 0xD001672A /end MEASUREMENT
/begin MEASUREMENT DSMRdy_stGrpRdyScan "" UWORD DSMRdy_OneToOne 1 100 0.00 65535.00 FORMAT "%8.2" ECU_ADDRESS 0xD0016728 /end MEASUREMENT
/begin MEASUREMENT DSMRdy_stGrpSup "" UWORD DSMRdy_OneToOne 1 100 0.00 65535.00 FORMAT "%8.2" ECU_ADDRESS 0xD001672C /end MEASUREMENT
/begin MEASUREMENT DSMRdy_Why.RdyMisf_mp "" UWORD DFCDSQ_Verb 1 100 0.00 427. FORMAT "%2.0" ECU_ADDRESS 0xD0016B46 /end MEASUREMENT
/begin MEASUREMENT DSMRdy_Why.RdyFlSys_mp "" UWORD DFCDSQ_Verb 1 100 0.00 427. FORMAT "%2.0" ECU_ADDRESS 0xD0016B48 /end MEASUREMENT
/begin MEASUREMENT DSMRdy_Why.RdyComprCmpnt_mp "" UWORD DFCDSQ_Verb 1 100 0.00 427. FORMAT "%2.0" ECU_ADDRESS 0xD0016B4A /end MEASUREMENT
/begin MEASUREMENT DSMRdy_Why.RdyCat_mp "" UWORD DFCDSQ_Verb 1 100 0.00 427. FORMAT "%2.0" ECU_ADDRESS 0xD0016B4C /end MEASUREMENT
/begin MEASUREMENT DSMRdy_Why.RdyHtCat_mp "" UWORD DFCDSQ_Verb 1 100 0.00 427. FORMAT "%2.0" ECU_ADDRESS 0xD0016B4E /end MEASUREMENT
/begin MEASUREMENT DSMRdy_Why.RdyEvpSys_mp "" UWORD DFCDSQ_Verb 1 100 0.00 427. FORMAT "%2.0" ECU_ADDRESS 0xD0016B50 /end MEASUREMENT
/begin MEASUREMENT DSMRdy_Why.RdySecAirSys_mp "" UWORD DFCDSQ_Verb 1 100 0.00 427. FORMAT "%2.0" ECU_ADDRESS 0xD0016B52 /end MEASUREMENT
/begin MEASUREMENT DSMRdy_Why.RdyAC_mp "" UWORD DFCDSQ_Verb 1 100 0.00 427. FORMAT "%2.0" ECU_ADDRESS 0xD0016B54 /end MEASUREMENT
/begin MEASUREMENT DSMRdy_Why.RdyO2Sens_mp "" UWORD DFCDSQ_Verb 1 100 0.00 427. FORMAT "%2.0" ECU_ADDRESS 0xD0016B56 /end MEASUREMENT
/begin MEASUREMENT DSMRdy_Why.RdyO2SensHt_mp "" UWORD DFCDSQ_Verb 1 100 0.00 427. FORMAT "%2.0" ECU_ADDRESS 0xD0016B58 /end MEASUREMENT
/begin MEASUREMENT DSMRdy_Why.RdyEGR_mp "" UWORD DFCDSQ_Verb 1 100 0.00 427. FORMAT "%2.0" ECU_ADDRESS 0xD0016B5A /end MEASUREMENT
/begin MEASUREMENT DSMRdy_Why.CyclCmplMisf_mp "" UWORD DFCDSQ_Verb 1 100 0.00 427. FORMAT "%2.0" ECU_ADDRESS 0xD0016B5C /end MEASUREMENT
/begin MEASUREMENT DSMRdy_Why.CyclCmplFlSys_mp "" UWORD DFCDSQ_Verb 1 100 0.00 427. FORMAT "%2.0" ECU_ADDRESS 0xD0016B5E /end MEASUREMENT
/begin MEASUREMENT DSMRdy_Why.CyclCmplComprCmpnt_mp "" UWORD DFCDSQ_Verb 1 100 0.00 427. FORMAT "%2.0" ECU_ADDRESS 0xD0016B60 /end MEASUREMENT
/begin MEASUREMENT DSMRdy_Why.CyclCmplCat_mp "" UWORD DFCDSQ_Verb 1 100 0.00 427. FORMAT "%2.0" ECU_ADDRESS 0xD0016B62 /end MEASUREMENT
/begin MEASUREMENT DSMRdy_Why.CyclCmplHtCat_mp "" UWORD DFCDSQ_Verb 1 100 0.00 427. FORMAT "%2.0" ECU_ADDRESS 0xD0016B64 /end MEASUREMENT
/begin MEASUREMENT DSMRdy_Why.CyclCmplEvpSys_mp "" UWORD DFCDSQ_Verb 1 100 0.00 427. FORMAT "%2.0" ECU_ADDRESS 0xD0016B66 /end MEASUREMENT
/begin MEASUREMENT DSMRdy_Why.CyclCmplSecAirSys_mp "" UWORD DFCDSQ_Verb 1 100 0.00 427. FORMAT "%2.0" ECU_ADDRESS 0xD0016B68 /end MEASUREMENT
/begin MEASUREMENT DSMRdy_Why.CyclCmplAC_mp "" UWORD DFCDSQ_Verb 1 100 0.00 427. FORMAT "%2.0" ECU_ADDRESS 0xD0016B6A /end MEASUREMENT
/begin MEASUREMENT DSMRdy_Why.CyclCmplO2Sens_mp "" UWORD DFCDSQ_Verb 1 100 0.00 427. FORMAT "%2.0" ECU_ADDRESS 0xD0016B6C /end MEASUREMENT
/begin MEASUREMENT DSMRdy_Why.CyclCmplO2SensHt_mp "" UWORD DFCDSQ_Verb 1 100 0.00 427. FORMAT "%2.0" ECU_ADDRESS 0xD0016B6E /end MEASUREMENT
/begin MEASUREMENT DSMRdy_Why.CyclCmplEGR_mp "" UWORD DFCDSQ_Verb 1 100 0.00 427. FORMAT "%2.0" ECU_ADDRESS 0xD0016B70 /end MEASUREMENT
/begin MEASUREMENT DSMRdy_Why.LockMisf_mp "" UWORD DFCDSQ_Verb 1 100 0.00 427. FORMAT "%2.0" ECU_ADDRESS 0xD0016B72 /end MEASUREMENT
/begin MEASUREMENT DSMRdy_Why.LockFlSys_mp "" UWORD DFCDSQ_Verb 1 100 0.00 427. FORMAT "%2.0" ECU_ADDRESS 0xD0016B74 /end MEASUREMENT
/begin MEASUREMENT DSMRdy_Why.LockComprCmpnt_mp "" UWORD DFCDSQ_Verb 1 100 0.00 427. FORMAT "%2.0" ECU_ADDRESS 0xD0016B76 /end MEASUREMENT
/begin MEASUREMENT DSMRdy_Why.LockCat_mp "" UWORD DFCDSQ_Verb 1 100 0.00 427. FORMAT "%2.0" ECU_ADDRESS 0xD0016B78 /end MEASUREMENT
/begin MEASUREMENT DSMRdy_Why.LockHtCat_mp "" UWORD DFCDSQ_Verb 1 100 0.00 427. FORMAT "%2.0" ECU_ADDRESS 0xD0016B7A /end MEASUREMENT
/begin MEASUREMENT DSMRdy_Why.LockEvpSys_mp "" UWORD DFCDSQ_Verb 1 100 0.00 427. FORMAT "%2.0" ECU_ADDRESS 0xD0016B7C /end MEASUREMENT
/begin MEASUREMENT DSMRdy_Why.LockSecAirSys_mp "" UWORD DFCDSQ_Verb 1 100 0.00 427. FORMAT "%2.0" ECU_ADDRESS 0xD0016B7E /end MEASUREMENT
/begin MEASUREMENT DSMRdy_Why.LockAC_mp "" UWORD DFCDSQ_Verb 1 100 0.00 427. FORMAT "%2.0" ECU_ADDRESS 0xD0016B80 /end MEASUREMENT
/begin MEASUREMENT DSMRdy_Why.LockO2Sens_mp "" UWORD DFCDSQ_Verb 1 100 0.00 427. FORMAT "%2.0" ECU_ADDRESS 0xD0016B82 /end MEASUREMENT
/begin MEASUREMENT DSMRdy_Why.LockO2SensHt_mp "" UWORD DFCDSQ_Verb 1 100 0.00 427. FORMAT "%2.0" ECU_ADDRESS 0xD0016B84 /end MEASUREMENT
/begin MEASUREMENT DSMRdy_Why.LockEGR_mp "" UWORD DFCDSQ_Verb 1 100 0.00 427. FORMAT "%2.0" ECU_ADDRESS 0xD0016B86 /end MEASUREMENT
/begin MEASUREMENT DSMRdy_xPId1 "" ULONG DSMRdy_OneToOne 1 100 0.00 4294967295.00 FORMAT "%13.2" ECU_ADDRESS 0xD0015430 /end MEASUREMENT
/begin MEASUREMENT DSMRdy_xPId41 "" ULONG DSMRdy_OneToOne 1 100 0.00 4294967295.00 FORMAT "%13.2" ECU_ADDRESS 0xD001B050 /end MEASUREMENT
/begin MEASUREMENT DSM_bStFuncTst_mp "" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0017D6C /end MEASUREMENT
/begin MEASUREMENT DSM_DisblMode_mp "" UWORD OneToOne 1 100 0.00 65535.00 FORMAT "%8.2" ECU_ADDRESS 0xD0017B0A /end MEASUREMENT
/begin MEASUREMENT DSM_ECUId_mp "" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0017D6D /end MEASUREMENT
/begin MEASUREMENT DSM_lDst_mp "" SLONG Length 1 100 -2147483648.00 2147483647.00 FORMAT "%13.2" ECU_ADDRESS 0xD0017908 /end MEASUREMENT
/begin MEASUREMENT DSM_nEng_mp "" SWORD EngN 1 100 -16384.00 16383.50 FORMAT "%8.2" ECU_ADDRESS 0xD0017B0C /end MEASUREMENT
/begin MEASUREMENT DSM_pEnv_mp "" SWORD Pres_hPa 1 100 -32768.00 32767.00 FORMAT "%8.2" ECU_ADDRESS 0xD0017B0E /end MEASUREMENT
/begin MEASUREMENT DSM_rAPP_mp "" SWORD Prc 1 100 -400.0000 399.9878 FORMAT "%8.4" ECU_ADDRESS 0xD0017B10 /end MEASUREMENT
/begin MEASUREMENT DSM_stFadeOut "" UWORD OneToOne 1 100 0.00 65535.00 FORMAT "%8.2" ECU_ADDRESS 0xD00000B6 /end MEASUREMENT
/begin MEASUREMENT DSM_stPostDrive "" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001738C /end MEASUREMENT
/begin MEASUREMENT DSM_stReInit "" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0016FEF /end MEASUREMENT
/begin MEASUREMENT DSM_stStrEnd_mp "" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0017D6E /end MEASUREMENT
/begin MEASUREMENT DSM_stWiggle_mp "" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0017D6F /end MEASUREMENT
/begin MEASUREMENT DSM_tEngDS_mp "" SWORD Temp_Cels 1 100 -3549.940 3003.560 FORMAT "%8.3" ECU_ADDRESS 0xD0017B12 /end MEASUREMENT
/begin MEASUREMENT DSM_tEnv_mp "" SWORD Temp_Cels 1 100 -3549.940 3003.560 FORMAT "%8.3" ECU_ADDRESS 0xD0017B14 /end MEASUREMENT
/begin MEASUREMENT DSM_vVeh_mp "" SWORD Vel 1 100 -327.6800 327.6700 FORMAT "%8.4" ECU_ADDRESS 0xD0017B16 /end MEASUREMENT
/begin MEASUREMENT DSM_xTabVersion "" UWORD DFC_OneToOne 1 100 0.00 65535.00 FORMAT "%8.2" ECU_ADDRESS 0xD0016AF6 /end MEASUREMENT
/begin MEASUREMENT DSQ_st.DSQ_DSMInhibitAlways "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001738E /end MEASUREMENT
/begin MEASUREMENT DSQ_st.DSQ_EpmReverseRun "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001738F /end MEASUREMENT
/begin MEASUREMENT DSQ_st.DSQ_MRly "" UBYTE DFC_OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0017390 /end MEASUREMENT
/begin MEASUREMENT DSQ_stClct_mp "" UWORD DFC_OneToOne 1 100 0.00 65535.00 FORMAT "%8.2" ARRAY_SIZE 1 ECU_ADDRESS 0xD0017AFC /end MEASUREMENT
/begin MEASUREMENT dtemnkt_w "Min-threshold for delta effective injection period" UWORD t1p0usxms 1 100 0.00 65.53500 FORMAT "%8.5" ECU_ADDRESS 0xD0001652 /end MEASUREMENT
/begin MEASUREMENT DTR_valLoLim.DTR_Dummy "" UWORD DFC_OneToOne 1 100 0.00 65535.00 FORMAT "%8.2" ECU_ADDRESS 0xD001AC0E /end MEASUREMENT
/begin MEASUREMENT DTR_valLoLim.DTR_OBDMID_01_TID_OCIA "" UWORD DFC_OneToOne 1 100 0.00 65535.00 FORMAT "%8.2" ECU_ADDRESS 0xD001AC10 /end MEASUREMENT
/begin MEASUREMENT DTR_valLoLim.DTR_OBDMID_01_TID_OCIP "" UWORD DFC_OneToOne 1 100 0.00 65535.00 FORMAT "%8.2" ECU_ADDRESS 0xD001AC12 /end MEASUREMENT
/begin MEASUREMENT DTR_valLoLim.DTR_OBDMID_05_TID_OCIA "" UWORD DFC_OneToOne 1 100 0.00 65535.00 FORMAT "%8.2" ECU_ADDRESS 0xD001AC14 /end MEASUREMENT
/begin MEASUREMENT DTR_valLoLim.DTR_OBDMID_05_TID_OCIP "" UWORD DFC_OneToOne 1 100 0.00 65535.00 FORMAT "%8.2" ECU_ADDRESS 0xD001AC16 /end MEASUREMENT
/begin MEASUREMENT DTR_valLoLim.DTR_dummy "" UWORD DFC_OneToOne 1 100 0.00 65535.00 FORMAT "%8.2" ECU_ADDRESS 0xD001AC18 /end MEASUREMENT
/begin MEASUREMENT DTR_valTst.DTR_Dummy "" UWORD DFC_OneToOne 1 100 0.00 65535.00 FORMAT "%8.2" ECU_ADDRESS 0xD001ABF6 /end MEASUREMENT
/begin MEASUREMENT DTR_valTst.DTR_OBDMID_01_TID_OCIA "" UWORD DFC_OneToOne 1 100 0.00 65535.00 FORMAT "%8.2" ECU_ADDRESS 0xD001ABF8 /end MEASUREMENT
/begin MEASUREMENT DTR_valTst.DTR_OBDMID_01_TID_OCIP "" UWORD DFC_OneToOne 1 100 0.00 65535.00 FORMAT "%8.2" ECU_ADDRESS 0xD001ABFA /end MEASUREMENT
/begin MEASUREMENT DTR_valTst.DTR_OBDMID_05_TID_OCIA "" UWORD DFC_OneToOne 1 100 0.00 65535.00 FORMAT "%8.2" ECU_ADDRESS 0xD001ABFC /end MEASUREMENT
/begin MEASUREMENT DTR_valTst.DTR_OBDMID_05_TID_OCIP "" UWORD DFC_OneToOne 1 100 0.00 65535.00 FORMAT "%8.2" ECU_ADDRESS 0xD001ABFE /end MEASUREMENT
/begin MEASUREMENT DTR_valTst.DTR_dummy "" UWORD DFC_OneToOne 1 100 0.00 65535.00 FORMAT "%8.2" ECU_ADDRESS 0xD001AC00 /end MEASUREMENT
/begin MEASUREMENT DTR_valUpLim.DTR_Dummy "" UWORD DFC_OneToOne 1 100 0.00 65535.00 FORMAT "%8.2" ECU_ADDRESS 0xD001AC02 /end MEASUREMENT
/begin MEASUREMENT DTR_valUpLim.DTR_OBDMID_01_TID_OCIA "" UWORD DFC_OneToOne 1 100 0.00 65535.00 FORMAT "%8.2" ECU_ADDRESS 0xD001AC04 /end MEASUREMENT
/begin MEASUREMENT DTR_valUpLim.DTR_OBDMID_01_TID_OCIP "" UWORD DFC_OneToOne 1 100 0.00 65535.00 FORMAT "%8.2" ECU_ADDRESS 0xD001AC06 /end MEASUREMENT
/begin MEASUREMENT DTR_valUpLim.DTR_OBDMID_05_TID_OCIA "" UWORD DFC_OneToOne 1 100 0.00 65535.00 FORMAT "%8.2" ECU_ADDRESS 0xD001AC08 /end MEASUREMENT
/begin MEASUREMENT DTR_valUpLim.DTR_OBDMID_05_TID_OCIP "" UWORD DFC_OneToOne 1 100 0.00 65535.00 FORMAT "%8.2" ECU_ADDRESS 0xD001AC0A /end MEASUREMENT
/begin MEASUREMENT DTR_valUpLim.DTR_dummy "" UWORD DFC_OneToOne 1 100 0.00 65535.00 FORMAT "%8.2" ECU_ADDRESS 0xD001AC0C /end MEASUREMENT
/begin MEASUREMENT duaip2_w "" UWORD spg_q4p88Em4 1 100 0.00 31.99951 FORMAT "%8.5" ECU_ADDRESS 0xD0000C74 /end MEASUREMENT
/begin MEASUREMENT duaipmn2_w "" UWORD spg_q4p88Em4 1 100 0.00 31.99951 FORMAT "%8.5" ECU_ADDRESS 0xD0000C76 /end MEASUREMENT
/begin MEASUREMENT duaipmn_w "" UWORD spg_q4p88Em4 1 100 0.00 31.99951 FORMAT "%8.5" ECU_ADDRESS 0xD0000C78 /end MEASUREMENT
/begin MEASUREMENT duaip_w "" UWORD spg_q4p88Em4 1 100 0.00 31.99951 FORMAT "%8.5" ECU_ADDRESS 0xD0000C7A /end MEASUREMENT
/begin MEASUREMENT duamx2_w "" UWORD spg_q4p88Em4 1 100 0.00 31.99951 FORMAT "%8.5" ECU_ADDRESS 0xD0000C7C /end MEASUREMENT
/begin MEASUREMENT duamx_w "" UWORD spg_q4p88Em4 1 100 0.00 31.99951 FORMAT "%8.5" ECU_ADDRESS 0xD0000C7E /end MEASUREMENT
/begin MEASUREMENT dwmsvd_w "Delivery duration of MFV in degrees crankshaft" SWORD kw_q0p1 1 100 -3276.800 3276.700 FORMAT "%8.3" ECU_ADDRESS 0xD0001654 /end MEASUREMENT
/begin MEASUREMENT dwmsvo_w "Angle - end of control MFV (opening)" SWORD kw_q0p1 1 100 -3276.800 3276.700 FORMAT "%8.3" ECU_ADDRESS 0xD000164C /end MEASUREMENT
/begin MEASUREMENT dwmsvs_w "Angle for begin of control of MFV including pick-up delay (closing)" UWORD kw_q0p1 1 100 0.00 6553.500 FORMAT "%8.3" ECU_ADDRESS 0xD000164E /end MEASUREMENT
/begin MEASUREMENT Eeebd_numSectChg "" UWORD OneToOne 1 100 0.00 65535.00 FORMAT "%8.2" ECU_ADDRESS 0xD001A626 /end MEASUREMENT
/begin MEASUREMENT Eeebd_stEee "" UBYTE Eeebd_EeeStates_Verb 1 100 0.00 3.00000000000 FORMAT "%13.11" ECU_ADDRESS 0xD0017394 /end MEASUREMENT
/begin MEASUREMENT Eep_ctAbsCallWrFkt "" UWORD OneToOne 1 100 0.00 65535.00 FORMAT "%8.2" ECU_ADDRESS 0xD001AF62 /end MEASUREMENT
/begin MEASUREMENT Eep_ctCallWrFkt "" UWORD OneToOne 1 100 0.00 65535.00 FORMAT "%8.2" ECU_ADDRESS 0xD001A59C /end MEASUREMENT
/begin MEASUREMENT Eep_ctMaxCallWrFkt "" UWORD OneToOne 1 100 0.00 65535.00 FORMAT "%8.2" ECU_ADDRESS 0xD001AF60 /end MEASUREMENT
/begin MEASUREMENT Eep_EnvRamHist "" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0016DF3 /end MEASUREMENT
/begin MEASUREMENT Eep_EnvRamInvld "" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0016DF2 /end MEASUREMENT
/begin MEASUREMENT Eep_numBlkCtr "" ULONG OneToOne 1 100 0.00 4294967295.00 FORMAT "%13.2" ARRAY_SIZE 26 ECU_ADDRESS 0xD001A528 /end MEASUREMENT
/begin MEASUREMENT Eep_numEnvRamLength "" UWORD OneToOne 1 100 0.00 65535.00 FORMAT "%8.2" ECU_ADDRESS 0xD00160D8 /end MEASUREMENT
/begin MEASUREMENT Eep_stBlk "" UWORD OneToOne 1 100 0.00 65535.00 FORMAT "%8.2" ARRAY_SIZE 25 ECU_ADDRESS 0xD0016732 /end MEASUREMENT
/begin MEASUREMENT Eep_stBlockFail "" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001A59A /end MEASUREMENT
/begin MEASUREMENT Eep_stMain "" UBYTE Eep_MainStates_Verb 1 100 0.00 12.0000000000 FORMAT "%13.10" ECU_ADDRESS 0xD0016DF6 /end MEASUREMENT
/begin MEASUREMENT Eep_stPostDrv "" UBYTE Eep_PostDrvState_Verb 1 100 0.00 4.00000000000 FORMAT "%13.11" ECU_ADDRESS 0xD0017014 /end MEASUREMENT
/begin MEASUREMENT Eep_xIniTimeus "" ULONG OneToOne 1 100 0.00 4294967295.00 FORMAT "%13.2" ECU_ADDRESS 0xD0005934 /end MEASUREMENT
/begin MEASUREMENT EngDa_tEng "" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0000471 /end MEASUREMENT
/begin MEASUREMENT EngDa_tiEngOn "" SLONG Length 1 100 -2147483648.00 2147483647.00 FORMAT "%13.2" ECU_ADDRESS 0xD0001E0C /end MEASUREMENT
/begin MEASUREMENT ENHLSF.B_hs "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD0000AFE /end MEASUREMENT
/begin MEASUREMENT ENHLSF.B_rehs "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x2 FORMAT "%13.11" ECU_ADDRESS 0xD0000AFF /end MEASUREMENT
/begin MEASUREMENT ENHLSF.B_tmoths "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD0000AFF /end MEASUREMENT
/begin MEASUREMENT ENHLSH.B_hs "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD0000B06 /end MEASUREMENT
/begin MEASUREMENT ENHLSH.B_rehs "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x2 FORMAT "%13.11" ECU_ADDRESS 0xD0000B07 /end MEASUREMENT
/begin MEASUREMENT ENHLSH.B_tmoths "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD0000B07 /end MEASUREMENT
/begin MEASUREMENT ENHLSV.B_hs "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD0000B0E /end MEASUREMENT
/begin MEASUREMENT ENHLSV.B_rehs "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x2 FORMAT "%13.11" ECU_ADDRESS 0xD0000B0F /end MEASUREMENT
/begin MEASUREMENT ENHLSV.B_tmoths "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD0000B0F /end MEASUREMENT
/begin MEASUREMENT EnvP_p "" SWORD Pres_hPa 1 100 -32768.00 32767.00 FORMAT "%8.2" ECU_ADDRESS 0xD000002C /end MEASUREMENT
/begin MEASUREMENT EnvT_t "" SWORD Temp_Cels 1 100 -3549.940 3003.560 FORMAT "%8.3" ECU_ADDRESS 0xD000002E /end MEASUREMENT
/begin MEASUREMENT EpmBCa_ctInjSer "" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0016D7C /end MEASUREMENT
/begin MEASUREMENT EpmBCa_ctTstInj "" UWORD OneToOne 1 100 0.00 65535.00 FORMAT "%8.2" ECU_ADDRESS 0xD0015FF4 /end MEASUREMENT
/begin MEASUREMENT EpmBCa_CurrCyl "" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0016D7D /end MEASUREMENT
/begin MEASUREMENT EpmBCa_facTimes_mp "" SWORD EpmBCa_FacTstInj 1 100 -32.76800 32.76700 FORMAT "%8.5" ECU_ADDRESS 0xD0017B18 /end MEASUREMENT
/begin MEASUREMENT EpmBCa_numCylInj "" UWORD OneToOne 1 100 0.00 65535.00 FORMAT "%8.2" ECU_ADDRESS 0xD0015FF6 /end MEASUREMENT
/begin MEASUREMENT EpmBCa_phiSegDst "" SWORD AngleCrS 1 100 -720.0000 719.9780 FORMAT "%8.4" ECU_ADDRESS 0xD0015FF8 /end MEASUREMENT
/begin MEASUREMENT EpmBCa_stInjMask "" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0000472 /end MEASUREMENT
/begin MEASUREMENT EpmBCa_stTstInj "" UBYTE EpmBCa_stTstInj_State_t 1 100 0.00 5.00000000000 FORMAT "%13.11" ECU_ADDRESS 0xD0016D7E /end MEASUREMENT
/begin MEASUREMENT EpmBCa_stTstInjRslt_mp "" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0017D70 /end MEASUREMENT
/begin MEASUREMENT EpmBCa_tiSegOld_mp "" SLONG OneToOne_us 1 100 -2147483648.00 2147483647.00 FORMAT "%13.2" ECU_ADDRESS 0xD001790C /end MEASUREMENT
/begin MEASUREMENT EpmBCa_tiSeg_mp "" SLONG OneToOne_us 1 100 -2147483648.00 2147483647.00 FORMAT "%13.2" ECU_ADDRESS 0xD0017910 /end MEASUREMENT
/begin MEASUREMENT EpmCaS_bActivatePatmat "" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ARRAY_SIZE 4 ECU_ADDRESS 0xD0016D7F /end MEASUREMENT
/begin MEASUREMENT EpmCaS_ctEdgeEquid "" SBYTE OneToOne 1 100 -128.0 127.0 FORMAT "%5.1" ARRAY_SIZE 4 ECU_ADDRESS 0xD0000143 /end MEASUREMENT
/begin MEASUREMENT EpmCaS_ctEdgeLst "" SWORD OneToOne 1 100 -32768.00 32767.00 FORMAT "%8.2" ARRAY_SIZE 4 ECU_ADDRESS 0xD0015FFA /end MEASUREMENT
/begin MEASUREMENT EpmCaS_ctErrSig "" UWORD CrSRev2CrSInc 1 100 0.00 1092.250 FORMAT "%8.3" ARRAY_SIZE 4 ECU_ADDRESS 0xD0016002 /end MEASUREMENT
/begin MEASUREMENT EpmCaS_ctNoSig "" UWORD CrSRev2CrSInc 1 100 0.00 1092.250 FORMAT "%8.3" ARRAY_SIZE 4 ECU_ADDRESS 0xD001600A /end MEASUREMENT
/begin MEASUREMENT EpmCaS_ctRevNoSig "" UWORD RevCnt 1 100 0.00 4095.938 FORMAT "%8.3" ARRAY_SIZE 4 ECU_ADDRESS 0xD0016012 /end MEASUREMENT
/begin MEASUREMENT EpmCaS_ctRevSig "" UWORD RevCnt 1 100 0.00 4095.938 FORMAT "%8.3" ARRAY_SIZE 4 ECU_ADDRESS 0xD001601A /end MEASUREMENT
/begin MEASUREMENT EpmCaS_ctSigOk "" UWORD CrSRev2CrSInc 1 100 0.00 1092.250 FORMAT "%8.3" ARRAY_SIZE 4 ECU_ADDRESS 0xD0016022 /end MEASUREMENT
/begin MEASUREMENT EpmCaS_nEng "" SWORD EngN 1 100 -16384.00 16383.50 FORMAT "%8.2" ECU_ADDRESS 0xD0000030 /end MEASUREMENT
/begin MEASUREMENT EpmCaS_numCurrEdge "" UWORD OneToOne 1 100 0.00 65535.00 FORMAT "%8.2" ARRAY_SIZE 4 ECU_ADDRESS 0xD001602A /end MEASUREMENT
/begin MEASUREMENT EpmCaS_phiAdapRefPosI2_mp "" SWORD AngleCrS 1 100 -720.0000 719.9780 FORMAT "%8.4" ARRAY_SIZE 48 ECU_ADDRESS 0xD0017B82 /end MEASUREMENT
/begin MEASUREMENT EpmCaS_phiAdapRefPosO2_mp "" SWORD AngleCrS 1 100 -720.0000 719.9780 FORMAT "%8.4" ARRAY_SIZE 48 ECU_ADDRESS 0xD0017C42 /end MEASUREMENT
/begin MEASUREMENT EpmCaS_phiCaSOfsAvg "" SLONG AngleCrS 1 100 -47185920.0000 47185919.9780 FORMAT "%13.4" ARRAY_SIZE 4 ECU_ADDRESS 0xD00155D8 /end MEASUREMENT
/begin MEASUREMENT EpmCaS_phiCor "" SWORD AngleCrS 1 100 -720.0000 719.9780 FORMAT "%8.4" ARRAY_SIZE 4 ECU_ADDRESS 0xD0000032 /end MEASUREMENT
/begin MEASUREMENT EpmCaS_phiDiffAvrgLim "" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0000473 /end MEASUREMENT
/begin MEASUREMENT EpmCaS_phiDiffCal2Adap "" SWORD AngleCrS 1 100 -720.0000 719.9780 FORMAT "%8.4" ARRAY_SIZE 192 ECU_ADDRESS 0xD00160E4 /end MEASUREMENT
/begin MEASUREMENT EpmCaS_phiDiffLim "" SWORD AngleCrS 1 100 -720.0000 719.9780 FORMAT "%8.4" ARRAY_SIZE 4 ECU_ADDRESS 0xD000003A /end MEASUREMENT
/begin MEASUREMENT EpmCaS_phiEdge "" SWORD AngleCrS 1 100 -720.0000 719.9780 FORMAT "%8.4" ARRAY_SIZE 4 ECU_ADDRESS 0xD0000042 /end MEASUREMENT
/begin MEASUREMENT EpmCaS_phiOfsCorr "" SWORD AngleCrS 1 100 -720.0000 719.9780 FORMAT "%8.4" ARRAY_SIZE 4 ECU_ADDRESS 0xD000004A /end MEASUREMENT
/begin MEASUREMENT EpmCaS_phiRefPos "" SWORD AngleCrS 1 100 -720.0000 719.9780 FORMAT "%8.4" ARRAY_SIZE 192 ECU_ADDRESS 0xD0016274 /end MEASUREMENT
/begin MEASUREMENT EpmCaS_phiTempCor "" SWORD AngleCrS 1 100 -720.0000 719.9780 FORMAT "%8.4" ARRAY_SIZE 4 ECU_ADDRESS 0xD0000052 /end MEASUREMENT
/begin MEASUREMENT EpmCaS_stAdap "" UBYTE EpmCaS_stAdap_State 1 100 0.00 4.00000000000 FORMAT "%13.11" ARRAY_SIZE 4 ECU_ADDRESS 0xD001AC24 /end MEASUREMENT
/begin MEASUREMENT EpmCaS_stAdapErr "" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ARRAY_SIZE 4 ECU_ADDRESS 0xD0016DF7 /end MEASUREMENT
/begin MEASUREMENT EpmCaS_stAgPhaShift_mp "" UBYTE EpmCaS_stAgPhaShift_t 1 100 0.00 3.00000000000 FORMAT "%13.11" ARRAY_SIZE 4 ECU_ADDRESS 0xD0017D7F /end MEASUREMENT
/begin MEASUREMENT EpmCaS_stCaSLvl "" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ARRAY_SIZE 4 ECU_ADDRESS 0xD0016D83 /end MEASUREMENT
/begin MEASUREMENT EpmCaS_stDiag "" UBYTE EpmCaS_stDiag_t 1 100 0.00 4.00000000000 FORMAT "%13.11" ARRAY_SIZE 4 ECU_ADDRESS 0xD0017017 /end MEASUREMENT
/begin MEASUREMENT EpmCaS_stDiagErr "" UBYTE EpmCaS_stDiagErr_t 1 100 0.00 3.00000000000 FORMAT "%13.11" ARRAY_SIZE 4 ECU_ADDRESS 0xD001701B /end MEASUREMENT
/begin MEASUREMENT EpmCaS_stNEng "" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0000474 /end MEASUREMENT
/begin MEASUREMENT EpmCaS_stOfs "" UBYTE EpmCas_stOfs_State 1 100 0.00 1.00000000000 FORMAT "%13.11" ARRAY_SIZE 4 ECU_ADDRESS 0xD001739E /end MEASUREMENT
/begin MEASUREMENT EpmCaS_stOfsErr "" UBYTE EpmCaS_stOfsErr_Val 1 100 0.00 5.00000000000 FORMAT "%13.11" ARRAY_SIZE 4 ECU_ADDRESS 0xD001739A /end MEASUREMENT
/begin MEASUREMENT EpmCaS_stPhaAdpn_mp "" UBYTE EpmCaS_stAdap_State 1 100 0.00 4.00000000000 FORMAT "%13.11" ARRAY_SIZE 4 ECU_ADDRESS 0xD0017D83 /end MEASUREMENT
/begin MEASUREMENT EpmCaS_stPhaRefAdpn_mp "" UBYTE EpmCaS_stAdap_State 1 100 0.00 4.00000000000 FORMAT "%13.11" ARRAY_SIZE 4 ECU_ADDRESS 0xD0017D87 /end MEASUREMENT
/begin MEASUREMENT EpmCaS_stphiDiffLim "" UBYTE EpmCaS_stphiDiffLim_t 1 100 0.00 8.00000000000 FORMAT "%13.11" ARRAY_SIZE 4 ECU_ADDRESS 0xD0000475 /end MEASUREMENT
/begin MEASUREMENT EpmCaS_stPosValid "" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ARRAY_SIZE 4 ECU_ADDRESS 0xD0016D8B /end MEASUREMENT
/begin MEASUREMENT EpmCaS_stSegFault "" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ARRAY_SIZE 4 ECU_ADDRESS 0xD0016D87 /end MEASUREMENT
/begin MEASUREMENT EpmCaS_tiDifAgPhaLstEdge_mp "" SLONG OneToOne_us 1 100 -2147483648.00 2147483647.00 FORMAT "%13.2" ARRAY_SIZE 4 ECU_ADDRESS 0xD0017914 /end MEASUREMENT
/begin MEASUREMENT EpmCaS_tiDifAgPhaLstTwoEdges_mp "" SLONG OneToOne_us 1 100 -2147483648.00 2147483647.00 FORMAT "%13.2" ARRAY_SIZE 4 ECU_ADDRESS 0xD0017924 /end MEASUREMENT
/begin MEASUREMENT EpmCaS_tiEdge "" SLONG Per_Dur 1 100 -2147483648.00 2147483647.00 FORMAT "%13.2" ARRAY_SIZE 4 ECU_ADDRESS 0xD0001E10 /end MEASUREMENT
/begin MEASUREMENT EpmCaS_tiNEngRstTimer "" SLONG Time_ms 1 100 -21474836480.0 21474836470.0 FORMAT "%13.1" ECU_ADDRESS 0xD00058CC /end MEASUREMENT
/begin MEASUREMENT EpmCrS_bDisturb "" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0016D8F /end MEASUREMENT
/begin MEASUREMENT EpmCrS_ctErrSig "" SWORD OneToOne 1 100 -32768.00 32767.00 FORMAT "%8.2" ECU_ADDRESS 0xD0016034 /end MEASUREMENT
/begin MEASUREMENT EpmCrS_ctErrSigSyncIni "" SWORD OneToOne 1 100 -32768.00 32767.00 FORMAT "%8.2" ECU_ADDRESS 0xD0016036 /end MEASUREMENT
/begin MEASUREMENT EpmCrS_ctInc "" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0000479 /end MEASUREMENT
/begin MEASUREMENT EpmCrS_ctRange "" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0016D9C /end MEASUREMENT
/begin MEASUREMENT EpmCrS_ctRev "" UWORD OneToOne 1 100 0.00 65535.00 FORMAT "%8.2" ECU_ADDRESS 0xD001603A /end MEASUREMENT
/begin MEASUREMENT EpmCrS_ctRevCnt "" UWORD RevCnt 1 100 0.00 4095.938 FORMAT "%8.3" ECU_ADDRESS 0xD0016048 /end MEASUREMENT
/begin MEASUREMENT EpmCrS_ctRevIni "" SWORD OneToOne 1 100 -32768.00 32767.00 FORMAT "%8.2" ECU_ADDRESS 0xD000005A /end MEASUREMENT
/begin MEASUREMENT EpmCrS_ctRevStrt "" SWORD OneToOne 1 100 -32768.00 32767.00 FORMAT "%8.2" ECU_ADDRESS 0xD000005C /end MEASUREMENT
/begin MEASUREMENT EpmCrS_ctRevStrtCont "" SWORD OneToOne 1 100 -32768.00 32767.00 FORMAT "%8.2" ECU_ADDRESS 0xD000005E /end MEASUREMENT
/begin MEASUREMENT EpmCrS_ctRevStrtExtd "" SLONG OneToOne 1 100 -2147483648.00 2147483647.00 FORMAT "%13.2" ECU_ADDRESS 0xD0001E20 /end MEASUREMENT
/begin MEASUREMENT EpmCrS_ctRevWaitDiag "" SWORD OneToOne 1 100 -32768.00 32767.00 FORMAT "%8.2" ECU_ADDRESS 0xD001603C /end MEASUREMENT
/begin MEASUREMENT EpmCrS_dnEngFltSyncIni "" SWORD EngNGrd 1 100 -16384.00 16383.50 FORMAT "%8.2" ECU_ADDRESS 0xD0016040 /end MEASUREMENT
/begin MEASUREMENT EpmCrS_numSeg "" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD000047A /end MEASUREMENT
/begin MEASUREMENT EpmCrS_phiIgnInc "" SWORD AngleCrS 1 100 -720.0000 719.9780 FORMAT "%8.4" ECU_ADDRESS 0xD0016046 /end MEASUREMENT
/begin MEASUREMENT EpmCrS_phiIntSeg "" SWORD AngleCrS 1 100 -720.0000 719.9780 FORMAT "%8.4" ECU_ADDRESS 0xD0000060 /end MEASUREMENT
/begin MEASUREMENT EpmCrS_phiSeg "" SWORD AngleCrS 1 100 -720.0000 719.9780 FORMAT "%8.4" ECU_ADDRESS 0xD0000062 /end MEASUREMENT
/begin MEASUREMENT EpmCrS_stDiag "" UBYTE EpmCrS_Diag_State 1 100 0.00 1.00000000000 FORMAT "%13.11" ECU_ADDRESS 0xD000047B /end MEASUREMENT
/begin MEASUREMENT EpmCrS_stDiagErrSig "" UBYTE EpmCrS_DiagResult_State 1 100 0.00 4.00000000000 FORMAT "%13.11" ECU_ADDRESS 0xD0016D9A /end MEASUREMENT
/begin MEASUREMENT EpmCrS_stDiagNoSig "" UBYTE EpmCrS_DiagResult_State 1 100 0.00 4.00000000000 FORMAT "%13.11" ECU_ADDRESS 0xD0016D9B /end MEASUREMENT
/begin MEASUREMENT EpmCrS_stSigDiagSrc "" UWORD OneToOne 1 100 0.00 65535.00 FORMAT "%8.2" ECU_ADDRESS 0xD0016044 /end MEASUREMENT
/begin MEASUREMENT EpmCrS_stSigMode "" UBYTE EpmHCrS_stSigMode_State_t 1 100 0.00 11.0000000000 FORMAT "%13.10" ECU_ADDRESS 0xD000047C /end MEASUREMENT
/begin MEASUREMENT EpmCrS_stT15 "" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0016D9E /end MEASUREMENT
/begin MEASUREMENT EpmCrS_tiIncPer "" SLONG GptaClc6_ti_COMPU 1 100 -858993459.200 858993458.800 FORMAT "%13.3" ECU_ADDRESS 0xD0001E24 /end MEASUREMENT
/begin MEASUREMENT EpmCrS_tiSeg "" SLONG Per_Dur 1 100 -2147483648.00 2147483647.00 FORMAT "%13.2" ECU_ADDRESS 0xD0001E28 /end MEASUREMENT
/begin MEASUREMENT EpmCrS_tiSegCurr "" SLONG Per_Dur 1 100 -2147483648.00 2147483647.00 FORMAT "%13.2" ECU_ADDRESS 0xD0001E2C /end MEASUREMENT
/begin MEASUREMENT EpmHCaS_numMaxTryPrepBuf "" SLONG OneToOne 1 100 -2147483648.00 2147483647.00 FORMAT "%13.2" ECU_ADDRESS 0xD00058D8 /end MEASUREMENT
/begin MEASUREMENT EpmHCrS_ctIncEngPos "" UWORD OneToOne 1 100 0.00 65535.00 FORMAT "%8.2" ECU_ADDRESS 0xD0005342 /end MEASUREMENT
/begin MEASUREMENT EpmHCrS_ctIncEngPosDev "" SWORD OneToOne 1 100 -32768.00 32767.00 FORMAT "%8.2" ECU_ADDRESS 0xD0016790 /end MEASUREMENT
/begin MEASUREMENT EpmHCrS_ctIncEngPosStrt "" UWORD OneToOne 1 100 0.00 65535.00 FORMAT "%8.2" ECU_ADDRESS 0xD0005340 /end MEASUREMENT
/begin MEASUREMENT EpmHCrS_ctResyncUpperLvl_mp "" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0017D8D /end MEASUREMENT
/begin MEASUREMENT EpmHCrS_stSigErr "" UWORD OneToOne 1 100 0.00 65535.00 FORMAT "%8.2" ECU_ADDRESS 0xD001678E /end MEASUREMENT
/begin MEASUREMENT EpmHCrS_stSigMode "" UBYTE EpmHCrS_stSigMode_State_t 1 100 0.00 11.0000000000 FORMAT "%13.10" ECU_ADDRESS 0xD001701F /end MEASUREMENT
/begin MEASUREMENT EpmHInt_tiInt4DelMeas "" ULONG OneToOne_us 1 100 0.00 4294967295.00 FORMAT "%13.2" ECU_ADDRESS 0xD00058DC /end MEASUREMENT
/begin MEASUREMENT EpmRRS_stRotDir "" UBYTE EpmRRS_stRotDir_t 1 100 0.00 2.00000000000 FORMAT "%13.11" ECU_ADDRESS 0xD000047E /end MEASUREMENT
/begin MEASUREMENT EpmSeq_numIncDiffInt "" SWORD OneToOne 1 100 -32768.00 32767.00 FORMAT "%8.2" ARRAY_SIZE 2 ECU_ADDRESS 0xD0000064 /end MEASUREMENT
/begin MEASUREMENT EpmSeq_numInt "" UBYTE EpmSeq_numInt_Compu 1 100 0.00 16.0000000000 FORMAT "%13.10" ECU_ADDRESS 0xD000047F /end MEASUREMENT
/begin MEASUREMENT EpmSeq_stInt "" UBYTE EpmSeq_stInt_Compu 1 100 0.00 8.00000000000 FORMAT "%13.11" ECU_ADDRESS 0xD0017020 /end MEASUREMENT
/begin MEASUREMENT EpmSyn_CaSData "" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ARRAY_SIZE 100 ECU_ADDRESS 0xD00163FA /end MEASUREMENT
/begin MEASUREMENT EpmSyn_ctEdgeEarly "" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ARRAY_SIZE 4 ECU_ADDRESS 0xD0016DA0 /end MEASUREMENT
/begin MEASUREMENT EpmSyn_ctEdgeLate "" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ARRAY_SIZE 4 ECU_ADDRESS 0xD0016DA4 /end MEASUREMENT
/begin MEASUREMENT EpmSyn_ctIncEngPos_10ms "" UWORD OneToOne 1 100 0.00 65535.00 FORMAT "%8.2" ECU_ADDRESS 0xD00000BA /end MEASUREMENT
/begin MEASUREMENT EpmSyn_EdgeFailType "" UBYTE EpmSyn_EdgeFailTypes 1 100 0.00 2.00000000000 FORMAT "%13.11" ARRAY_SIZE 4 ECU_ADDRESS 0xD0016DA8 /end MEASUREMENT
/begin MEASUREMENT EpmSyn_numCaSSync "" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0016DB0 /end MEASUREMENT
/begin MEASUREMENT EpmSyn_numIntTyp "" ULONG OneToOne 1 100 0.00 4294967295.00 FORMAT "%13.2" ECU_ADDRESS 0xD0001E3C /end MEASUREMENT
/begin MEASUREMENT EpmSyn_numMatchPos "" SBYTE OneToOne 1 100 -128.0 127.0 FORMAT "%5.1" ARRAY_SIZE 4 ECU_ADDRESS 0xD0016DAC /end MEASUREMENT
/begin MEASUREMENT EpmSyn_phiCaSPos "" SWORD AngleCrS 1 100 -720.0000 719.9780 FORMAT "%8.4" ARRAY_SIZE 4 ECU_ADDRESS 0xD0016054 /end MEASUREMENT
/begin MEASUREMENT EpmSyn_phiCaSPosCorrAdap "" SWORD AngleCrS 1 100 -720.0000 719.9780 FORMAT "%8.4" ARRAY_SIZE 4 ECU_ADDRESS 0xD001604C /end MEASUREMENT
/begin MEASUREMENT EpmSyn_phiDiff "" SWORD AngleCrS 1 100 -720.0000 719.9780 FORMAT "%8.4" ECU_ADDRESS 0xD0000068 /end MEASUREMENT
/begin MEASUREMENT EpmSyn_phiInt "" SWORD AngleCrS 1 100 -720.0000 719.9780 FORMAT "%8.4" ECU_ADDRESS 0xD000006A /end MEASUREMENT
/begin MEASUREMENT EpmSyn_phiOffs "" SWORD AngleCrS 1 100 -720.0000 719.9780 FORMAT "%8.4" ECU_ADDRESS 0xD00165A2 /end MEASUREMENT
/begin MEASUREMENT EpmSyn_phiOffsCor "" SWORD AngleCrS 1 100 -720.0000 719.9780 FORMAT "%8.4" ECU_ADDRESS 0xD00165A4 /end MEASUREMENT
/begin MEASUREMENT EpmSyn_phiSegLenUncorr "" SLONG AngleCrS 1 100 -47185920.0000 47185919.9780 FORMAT "%13.4" ARRAY_SIZE 4 ECU_ADDRESS 0xD00058E0 /end MEASUREMENT
/begin MEASUREMENT EpmSyn_stCasEval "" UBYTE EpmSyn_stCaSEvalComp 1 100 0.00 4.00000000000 FORMAT "%13.11" ECU_ADDRESS 0xD0016FC1 /end MEASUREMENT
/begin MEASUREMENT EpmSyn_stCaSPos "" UBYTE EpmSyn_stCaSPosComp 1 100 0.00 20.0000000000 FORMAT "%13.10" ARRAY_SIZE 4 ECU_ADDRESS 0xD0016E35 /end MEASUREMENT
/begin MEASUREMENT EpmSyn_stCrSPos "" UBYTE EpmSyn_stCrSPos_State_t 1 100 0.00 3.00000000000 FORMAT "%13.11" ECU_ADDRESS 0xD0000481 /end MEASUREMENT
/begin MEASUREMENT EpmSyn_stCrSPosErr "" UWORD OneToOne 1 100 0.00 65535.00 FORMAT "%8.2" ECU_ADDRESS 0xD00165A6 /end MEASUREMENT
/begin MEASUREMENT EpmSyn_stGapPos "" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0016FC2 /end MEASUREMENT
/begin MEASUREMENT Epm_ctCyl "Current cylinder number" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0000486 /end MEASUREMENT
/begin MEASUREMENT Epm_ctReSync "" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0016DB3 /end MEASUREMENT
/begin MEASUREMENT Epm_dnEng "" SWORD EngNGrd 1 100 -16384.00 16383.50 FORMAT "%8.2" ECU_ADDRESS 0xD000006C /end MEASUREMENT
/begin MEASUREMENT Epm_dnEngAvg "" SWORD EngNGrd 1 100 -16384.00 16383.50 FORMAT "%8.2" ECU_ADDRESS 0xD000006E /end MEASUREMENT
/begin MEASUREMENT Epm_dnEngAvgFlt "" SWORD EngNGrd 1 100 -16384.00 16383.50 FORMAT "%8.2" ECU_ADDRESS 0xD0000070 /end MEASUREMENT
/begin MEASUREMENT Epm_dnEngFlt "" SWORD EngNGrd 1 100 -16384.00 16383.50 FORMAT "%8.2" ECU_ADDRESS 0xD0000072 /end MEASUREMENT
/begin MEASUREMENT Epm_nEng "" SWORD EngN 1 100 -16384.00 16383.50 FORMAT "%8.2" ECU_ADDRESS 0xD0000076 /end MEASUREMENT
/begin MEASUREMENT Epm_nEng10ms "" SWORD EngN 1 100 -16384.00 16383.50 FORMAT "%8.2" ECU_ADDRESS 0xD0000074 /end MEASUREMENT
/begin MEASUREMENT Epm_nEngCurr "" SWORD EngN 1 100 -16384.00 16383.50 FORMAT "%8.2" ECU_ADDRESS 0xD0000078 /end MEASUREMENT
/begin MEASUREMENT Epm_nEngDiff "" SWORD EngN 1 100 -16384.00 16383.50 FORMAT "%8.2" ECU_ADDRESS 0xD000007A /end MEASUREMENT
/begin MEASUREMENT Epm_nEngDiffAvg "" SWORD EngN 1 100 -16384.00 16383.50 FORMAT "%8.2" ECU_ADDRESS 0xD000007C /end MEASUREMENT
/begin MEASUREMENT Epm_nEngInc10ms "" SWORD EngN 1 100 -16384.00 16383.50 FORMAT "%8.2" ECU_ADDRESS 0xD000007E /end MEASUREMENT
/begin MEASUREMENT Epm_nEngLRes "" UBYTE EngN_LRes 1 100 0.00 10200. FORMAT "%5.0" ECU_ADDRESS 0xD0000487 /end MEASUREMENT
/begin MEASUREMENT Epm_nEngRaw "" SWORD EngN 1 100 -16384.00 16383.50 FORMAT "%8.2" ECU_ADDRESS 0xD0000080 /end MEASUREMENT
/begin MEASUREMENT Epm_nEngTooth10ms "" SWORD EngN 1 100 -16384.00 16383.50 FORMAT "%8.2" ECU_ADDRESS 0xD0000082 /end MEASUREMENT
/begin MEASUREMENT Epm_nEngVerify "" SWORD EngN 1 100 -16384.00 16383.50 FORMAT "%8.2" ECU_ADDRESS 0xD001606C /end MEASUREMENT
/begin MEASUREMENT Epm_numConfCaS "" UWORD OneToOne 1 100 0.00 65535.00 FORMAT "%8.2" ECU_ADDRESS 0xD000533E /end MEASUREMENT
/begin MEASUREMENT Epm_numConfCrS "" ULONG OneToOne 1 100 0.00 4294967295.00 FORMAT "%13.2" ECU_ADDRESS 0xD0002BC8 /end MEASUREMENT
/begin MEASUREMENT Epm_phiCyl "" SWORD AngleCrS 1 100 -720.0000 719.9780 FORMAT "%8.4" ARRAY_SIZE 8 ECU_ADDRESS 0xD001605C /end MEASUREMENT
/begin MEASUREMENT Epm_phiDiffTDC "" SWORD AngleCrS 1 100 -720.0000 719.9780 FORMAT "%8.4" ECU_ADDRESS 0xD0000084 /end MEASUREMENT
/begin MEASUREMENT Epm_phiHCrsGetCurrPos "" SWORD AngleCrS 1 100 -720.0000 719.9780 FORMAT "%8.4" ECU_ADDRESS 0xD001606E /end MEASUREMENT
/begin MEASUREMENT Epm_stCmbTestReq "" UBYTE Epm_stCmbTestReq_State_t 1 100 0.00 10.0000000000 FORMAT "%13.10" ECU_ADDRESS 0xD0000489 /end MEASUREMENT
/begin MEASUREMENT Epm_stOpMode "State of operation mode" UBYTE Epm_stOpMode_State_t 1 100 1.00000000000 60.0000000000 FORMAT "%13.10" ECU_ADDRESS 0xD000048A /end MEASUREMENT
/begin MEASUREMENT Epm_stSpd "" UBYTE Epm_stSpd_t 1 100 0.00 4.00000000000 FORMAT "%13.11" ECU_ADDRESS 0xD000048B /end MEASUREMENT
/begin MEASUREMENT Epm_stSync "" UBYTE Epm_stSync_State_t 1 100 0.00 30.0000000000 FORMAT "%13.10" ECU_ADDRESS 0xD000048C /end MEASUREMENT
/begin MEASUREMENT Epm_stSyncRestore "" UBYTE Epm_stOpMode_State_t 1 100 1.00000000000 60.0000000000 FORMAT "%13.10" ECU_ADDRESS 0xD0016DB1 /end MEASUREMENT
/begin MEASUREMENT Epm_stTestInj "" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0016DB2 /end MEASUREMENT
/begin MEASUREMENT Epm_tiSpd2Zero "" UWORD Time_ms 1 100 0.00 655350.0 FORMAT "%8.1" ECU_ADDRESS 0xD0016070 /end MEASUREMENT
/begin MEASUREMENT ErrLmp_stMIL "" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD000048D /end MEASUREMENT
/begin MEASUREMENT ESC_stErr "" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD00173DD /end MEASUREMENT
/begin MEASUREMENT ESC_tiSampling "" SLONG Per_Dur 1 100 -2147483648.00 2147483647.00 FORMAT "%13.2" ECU_ADDRESS 0xD00155F8 /end MEASUREMENT
/begin MEASUREMENT Etc_ctCurRunTst "" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD000048E /end MEASUREMENT
/begin MEASUREMENT evz_austot "" UBYTE dez 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0001859 /end MEASUREMENT
/begin MEASUREMENT evz_austot_w "" UWORD dez 1 100 0.00 65535.00 FORMAT "%8.2" ECU_ADDRESS 0xD0001656 /end MEASUREMENT
/begin MEASUREMENT Fan_stShutOff "" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD000048F /end MEASUREMENT
/begin MEASUREMENT fmfkrnew_w "KR filter selection next combustion" SWORD dez 1 100 -32768.00 32767.00 FORMAT "%8.2" ECU_ADDRESS 0xD000165A /end MEASUREMENT
/begin MEASUREMENT frm2_w "fast mean value of lambda control factor bank 2(word)" UWORD fak_uw_b2 1 100 0.00 1.999969 FORMAT "%8.6" ECU_ADDRESS 0xD000165C /end MEASUREMENT
/begin MEASUREMENT Frm_stCANG1_HDL0Rdy "Enable/Ready bit of the message buffer for Group 1 and Hanlde 0" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0000490 /end MEASUREMENT
/begin MEASUREMENT Frm_stCANG1_HDL10Rdy "Enable/Ready bit of the message buffer for Group 1 and Hanlde 10" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0000491 /end MEASUREMENT
/begin MEASUREMENT Frm_stCANG1_HDL11Rdy "Enable/Ready bit of the message buffer for Group 1 and Hanlde 11" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0000492 /end MEASUREMENT
/begin MEASUREMENT Frm_stCANG1_HDL12Rdy "Enable/Ready bit of the message buffer for Group 1 and Hanlde 12" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0000493 /end MEASUREMENT
/begin MEASUREMENT Frm_stCANG1_HDL13Rdy "Enable/Ready bit of the message buffer for Group 1 and Hanlde 13" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0000494 /end MEASUREMENT
/begin MEASUREMENT Frm_stCANG1_HDL14Rdy "Enable/Ready bit of the message buffer for Group 1 and Hanlde 14" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0000495 /end MEASUREMENT
/begin MEASUREMENT Frm_stCANG1_HDL15Rdy "Enable/Ready bit of the message buffer for Group 1 and Hanlde 15" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0000496 /end MEASUREMENT
/begin MEASUREMENT Frm_stCANG1_HDL16Rdy "Enable/Ready bit of the message buffer for Group 1 and Hanlde 16" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0000497 /end MEASUREMENT
/begin MEASUREMENT Frm_stCANG1_HDL17Rdy "Enable/Ready bit of the message buffer for Group 1 and Hanlde 17" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0000498 /end MEASUREMENT
/begin MEASUREMENT Frm_stCANG1_HDL18Rdy "Enable/Ready bit of the message buffer for Group 1 and Hanlde 18" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0000499 /end MEASUREMENT
/begin MEASUREMENT Frm_stCANG1_HDL19Rdy "Enable/Ready bit of the message buffer for Group 1 and Hanlde 19" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD000049A /end MEASUREMENT
/begin MEASUREMENT Frm_stCANG1_HDL1Rdy "Enable/Ready bit of the message buffer for Group 1 and Hanlde 1" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD000049B /end MEASUREMENT
/begin MEASUREMENT Frm_stCANG1_HDL20Rdy "Enable/Ready bit of the message buffer for Group 1 and Hanlde 20" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD000049C /end MEASUREMENT
/begin MEASUREMENT Frm_stCANG1_HDL21Rdy "Enable/Ready bit of the message buffer for Group 1 and Hanlde 21" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD000049D /end MEASUREMENT
/begin MEASUREMENT Frm_stCANG1_HDL22Rdy "Enable/Ready bit of the message buffer for Group 1 and Hanlde 22" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD000049E /end MEASUREMENT
/begin MEASUREMENT Frm_stCANG1_HDL23Rdy "Enable/Ready bit of the message buffer for Group 1 and Hanlde 23" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD000049F /end MEASUREMENT
/begin MEASUREMENT Frm_stCANG1_HDL24Rdy "Enable/Ready bit of the message buffer for Group 1 and Hanlde 24" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD00004A0 /end MEASUREMENT
/begin MEASUREMENT Frm_stCANG1_HDL2Rdy "Enable/Ready bit of the message buffer for Group 1 and Hanlde 2" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD00004A1 /end MEASUREMENT
/begin MEASUREMENT Frm_stCANG1_HDL3Rdy "Enable/Ready bit of the message buffer for Group 1 and Hanlde 3" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD00004A2 /end MEASUREMENT
/begin MEASUREMENT Frm_stCANG1_HDL4Rdy "Enable/Ready bit of the message buffer for Group 1 and Hanlde 4" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD00004A3 /end MEASUREMENT
/begin MEASUREMENT Frm_stCANG1_HDL5Rdy "Enable/Ready bit of the message buffer for Group 1 and Hanlde 5" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD00004A4 /end MEASUREMENT
/begin MEASUREMENT Frm_stCANG1_HDL6Rdy "Enable/Ready bit of the message buffer for Group 1 and Hanlde 6" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD00004A5 /end MEASUREMENT
/begin MEASUREMENT Frm_stCANG1_HDL7Rdy "Enable/Ready bit of the message buffer for Group 1 and Hanlde 7" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD00004A6 /end MEASUREMENT
/begin MEASUREMENT Frm_stCANG1_HDL8Rdy "Enable/Ready bit of the message buffer for Group 1 and Hanlde 8" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD00004A7 /end MEASUREMENT
/begin MEASUREMENT Frm_stCANG1_HDL9Rdy "Enable/Ready bit of the message buffer for Group 1 and Hanlde 9" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD00004A8 /end MEASUREMENT
/begin MEASUREMENT Frm_stCANG2_HDL0Rdy "Enable/Ready bit of the message buffer for Group 2 and Hanlde 0" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD00004A9 /end MEASUREMENT
/begin MEASUREMENT Frm_stCANG2_HDL10Rdy "Enable/Ready bit of the message buffer for Group 2 and Hanlde 10" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD00004AA /end MEASUREMENT
/begin MEASUREMENT Frm_stCANG2_HDL11Rdy "Enable/Ready bit of the message buffer for Group 2 and Hanlde 11" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD00004AB /end MEASUREMENT
/begin MEASUREMENT Frm_stCANG2_HDL12Rdy "Enable/Ready bit of the message buffer for Group 2 and Hanlde 12" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD00004AC /end MEASUREMENT
/begin MEASUREMENT Frm_stCANG2_HDL13Rdy "Enable/Ready bit of the message buffer for Group 2 and Hanlde 13" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD00004AD /end MEASUREMENT
/begin MEASUREMENT Frm_stCANG2_HDL14Rdy "Enable/Ready bit of the message buffer for Group 2 and Hanlde 14" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD00004AE /end MEASUREMENT
/begin MEASUREMENT Frm_stCANG2_HDL15Rdy "Enable/Ready bit of the message buffer for Group 2 and Hanlde 15" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD00004AF /end MEASUREMENT
/begin MEASUREMENT Frm_stCANG2_HDL16Rdy "Enable/Ready bit of the message buffer for Group 2 and Hanlde 16" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD00004B0 /end MEASUREMENT
/begin MEASUREMENT Frm_stCANG2_HDL17Rdy "Enable/Ready bit of the message buffer for Group 2 and Hanlde 17" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD00004B1 /end MEASUREMENT
/begin MEASUREMENT Frm_stCANG2_HDL18Rdy "Enable/Ready bit of the message buffer for Group 2 and Hanlde 18" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD00004B2 /end MEASUREMENT
/begin MEASUREMENT Frm_stCANG2_HDL19Rdy "Enable/Ready bit of the message buffer for Group 2 and Hanlde 19" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD00004B3 /end MEASUREMENT
/begin MEASUREMENT Frm_stCANG2_HDL1Rdy "Enable/Ready bit of the message buffer for Group 2 and Hanlde 1" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD00004B4 /end MEASUREMENT
/begin MEASUREMENT Frm_stCANG2_HDL20Rdy "Enable/Ready bit of the message buffer for Group 2 and Hanlde 20" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD00004B5 /end MEASUREMENT
/begin MEASUREMENT Frm_stCANG2_HDL21Rdy "Enable/Ready bit of the message buffer for Group 2 and Hanlde 21" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD00004B6 /end MEASUREMENT
/begin MEASUREMENT Frm_stCANG2_HDL22Rdy "Enable/Ready bit of the message buffer for Group 2 and Hanlde 22" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD00004B7 /end MEASUREMENT
/begin MEASUREMENT Frm_stCANG2_HDL23Rdy "Enable/Ready bit of the message buffer for Group 2 and Hanlde 23" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD00004B8 /end MEASUREMENT
/begin MEASUREMENT Frm_stCANG2_HDL24Rdy "Enable/Ready bit of the message buffer for Group 2 and Hanlde 24" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD00004B9 /end MEASUREMENT
/begin MEASUREMENT Frm_stCANG2_HDL2Rdy "Enable/Ready bit of the message buffer for Group 2 and Hanlde 2" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD00004BA /end MEASUREMENT
/begin MEASUREMENT Frm_stCANG2_HDL3Rdy "Enable/Ready bit of the message buffer for Group 2 and Hanlde 3" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD00004BB /end MEASUREMENT
/begin MEASUREMENT Frm_stCANG2_HDL4Rdy "Enable/Ready bit of the message buffer for Group 2 and Hanlde 4" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD00004BC /end MEASUREMENT
/begin MEASUREMENT Frm_stCANG2_HDL5Rdy "Enable/Ready bit of the message buffer for Group 2 and Hanlde 5" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD00004BD /end MEASUREMENT
/begin MEASUREMENT Frm_stCANG2_HDL6Rdy "Enable/Ready bit of the message buffer for Group 2 and Hanlde 6" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD00004BE /end MEASUREMENT
/begin MEASUREMENT Frm_stCANG2_HDL7Rdy "Enable/Ready bit of the message buffer for Group 2 and Hanlde 7" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD00004BF /end MEASUREMENT
/begin MEASUREMENT Frm_stCANG2_HDL8Rdy "Enable/Ready bit of the message buffer for Group 2 and Hanlde 8" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD00004C0 /end MEASUREMENT
/begin MEASUREMENT Frm_stCANG2_HDL9Rdy "Enable/Ready bit of the message buffer for Group 2 and Hanlde 9" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD00004C1 /end MEASUREMENT
/begin MEASUREMENT Frm_stCANG3_HDL0Rdy "Enable/Ready bit of the message buffer for Group 3 and Hanlde 0" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD00004C2 /end MEASUREMENT
/begin MEASUREMENT Frm_stCANG3_HDL10Rdy "Enable/Ready bit of the message buffer for Group 3 and Hanlde 10" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD00004C3 /end MEASUREMENT
/begin MEASUREMENT Frm_stCANG3_HDL11Rdy "Enable/Ready bit of the message buffer for Group 3 and Hanlde 11" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD00004C4 /end MEASUREMENT
/begin MEASUREMENT Frm_stCANG3_HDL12Rdy "Enable/Ready bit of the message buffer for Group 3 and Hanlde 12" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD00004C5 /end MEASUREMENT
/begin MEASUREMENT Frm_stCANG3_HDL13Rdy "Enable/Ready bit of the message buffer for Group 3 and Hanlde 13" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD00004C6 /end MEASUREMENT
/begin MEASUREMENT Frm_stCANG3_HDL14Rdy "Enable/Ready bit of the message buffer for Group 3 and Hanlde 14" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD00004C7 /end MEASUREMENT
/begin MEASUREMENT Frm_stCANG3_HDL15Rdy "Enable/Ready bit of the message buffer for Group 3 and Hanlde 15" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD00004C8 /end MEASUREMENT
/begin MEASUREMENT Frm_stCANG3_HDL16Rdy "Enable/Ready bit of the message buffer for Group 3 and Hanlde 16" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD00004C9 /end MEASUREMENT
/begin MEASUREMENT Frm_stCANG3_HDL17Rdy "Enable/Ready bit of the message buffer for Group 3 and Hanlde 17" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD00004CA /end MEASUREMENT
/begin MEASUREMENT Frm_stCANG3_HDL18Rdy "Enable/Ready bit of the message buffer for Group 3 and Hanlde 18" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD00004CB /end MEASUREMENT
/begin MEASUREMENT Frm_stCANG3_HDL19Rdy "Enable/Ready bit of the message buffer for Group 3 and Hanlde 19" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD00004CC /end MEASUREMENT
/begin MEASUREMENT Frm_stCANG3_HDL1Rdy "Enable/Ready bit of the message buffer for Group 3 and Hanlde 1" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD00004CD /end MEASUREMENT
/begin MEASUREMENT Frm_stCANG3_HDL20Rdy "Enable/Ready bit of the message buffer for Group 3 and Hanlde 20" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD00004CE /end MEASUREMENT
/begin MEASUREMENT Frm_stCANG3_HDL21Rdy "Enable/Ready bit of the message buffer for Group 3 and Hanlde 21" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD00004CF /end MEASUREMENT
/begin MEASUREMENT Frm_stCANG3_HDL22Rdy "Enable/Ready bit of the message buffer for Group 3 and Hanlde 22" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD00004D0 /end MEASUREMENT
/begin MEASUREMENT Frm_stCANG3_HDL23Rdy "Enable/Ready bit of the message buffer for Group 3 and Hanlde 23" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD00004D1 /end MEASUREMENT
/begin MEASUREMENT Frm_stCANG3_HDL24Rdy "Enable/Ready bit of the message buffer for Group 3 and Hanlde 24" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD00004D2 /end MEASUREMENT
/begin MEASUREMENT Frm_stCANG3_HDL2Rdy "Enable/Ready bit of the message buffer for Group 3 and Hanlde 2" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD00004D3 /end MEASUREMENT
/begin MEASUREMENT Frm_stCANG3_HDL3Rdy "Enable/Ready bit of the message buffer for Group 3 and Hanlde 3" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD00004D4 /end MEASUREMENT
/begin MEASUREMENT Frm_stCANG3_HDL4Rdy "Enable/Ready bit of the message buffer for Group 3 and Hanlde 4" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD00004D5 /end MEASUREMENT
/begin MEASUREMENT Frm_stCANG3_HDL5Rdy "Enable/Ready bit of the message buffer for Group 3 and Hanlde 5" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD00004D6 /end MEASUREMENT
/begin MEASUREMENT Frm_stCANG3_HDL6Rdy "Enable/Ready bit of the message buffer for Group 3 and Hanlde 6" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD00004D7 /end MEASUREMENT
/begin MEASUREMENT Frm_stCANG3_HDL7Rdy "Enable/Ready bit of the message buffer for Group 3 and Hanlde 7" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD00004D8 /end MEASUREMENT
/begin MEASUREMENT Frm_stCANG3_HDL8Rdy "Enable/Ready bit of the message buffer for Group 3 and Hanlde 8" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD00004D9 /end MEASUREMENT
/begin MEASUREMENT Frm_stCANG3_HDL9Rdy "Enable/Ready bit of the message buffer for Group 3 and Hanlde 9" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD00004DA /end MEASUREMENT
/begin MEASUREMENT Frm_stCANG4_HDL0Rdy "Enable/Ready bit of the message buffer for Group 4 and Hanlde 0" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD00004DB /end MEASUREMENT
/begin MEASUREMENT Frm_stCANG4_HDL10Rdy "Enable/Ready bit of the message buffer for Group 4 and Hanlde 10" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD00004DC /end MEASUREMENT
/begin MEASUREMENT Frm_stCANG4_HDL11Rdy "Enable/Ready bit of the message buffer for Group 4 and Hanlde 11" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD00004DD /end MEASUREMENT
/begin MEASUREMENT Frm_stCANG4_HDL12Rdy "Enable/Ready bit of the message buffer for Group 4 and Hanlde 12" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD00004DE /end MEASUREMENT
/begin MEASUREMENT Frm_stCANG4_HDL13Rdy "Enable/Ready bit of the message buffer for Group 4 and Hanlde 13" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD00004DF /end MEASUREMENT
/begin MEASUREMENT Frm_stCANG4_HDL14Rdy "Enable/Ready bit of the message buffer for Group 4 and Hanlde 14" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD00004E0 /end MEASUREMENT
/begin MEASUREMENT Frm_stCANG4_HDL15Rdy "Enable/Ready bit of the message buffer for Group 4 and Hanlde 15" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD00004E1 /end MEASUREMENT
/begin MEASUREMENT Frm_stCANG4_HDL16Rdy "Enable/Ready bit of the message buffer for Group 4 and Hanlde 16" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD00004E2 /end MEASUREMENT
/begin MEASUREMENT Frm_stCANG4_HDL17Rdy "Enable/Ready bit of the message buffer for Group 4 and Hanlde 17" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD00004E3 /end MEASUREMENT
/begin MEASUREMENT Frm_stCANG4_HDL18Rdy "Enable/Ready bit of the message buffer for Group 4 and Hanlde 18" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD00004E4 /end MEASUREMENT
/begin MEASUREMENT Frm_stCANG4_HDL19Rdy "Enable/Ready bit of the message buffer for Group 4 and Hanlde 19" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD00004E5 /end MEASUREMENT
/begin MEASUREMENT Frm_stCANG4_HDL1Rdy "Enable/Ready bit of the message buffer for Group 4 and Hanlde 1" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD00004E6 /end MEASUREMENT
/begin MEASUREMENT Frm_stCANG4_HDL20Rdy "Enable/Ready bit of the message buffer for Group 4 and Hanlde 20" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD00004E7 /end MEASUREMENT
/begin MEASUREMENT Frm_stCANG4_HDL21Rdy "Enable/Ready bit of the message buffer for Group 4 and Hanlde 21" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD00004E8 /end MEASUREMENT
/begin MEASUREMENT Frm_stCANG4_HDL22Rdy "Enable/Ready bit of the message buffer for Group 4 and Hanlde 22" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD00004E9 /end MEASUREMENT
/begin MEASUREMENT Frm_stCANG4_HDL23Rdy "Enable/Ready bit of the message buffer for Group 4 and Hanlde 23" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD00004EA /end MEASUREMENT
/begin MEASUREMENT Frm_stCANG4_HDL24Rdy "Enable/Ready bit of the message buffer for Group 4 and Hanlde 24" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD00004EB /end MEASUREMENT
/begin MEASUREMENT Frm_stCANG4_HDL2Rdy "Enable/Ready bit of the message buffer for Group 4 and Hanlde 2" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD00004EC /end MEASUREMENT
/begin MEASUREMENT Frm_stCANG4_HDL3Rdy "Enable/Ready bit of the message buffer for Group 4 and Hanlde 3" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD00004ED /end MEASUREMENT
/begin MEASUREMENT Frm_stCANG4_HDL4Rdy "Enable/Ready bit of the message buffer for Group 4 and Hanlde 4" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD00004EE /end MEASUREMENT
/begin MEASUREMENT Frm_stCANG4_HDL5Rdy "Enable/Ready bit of the message buffer for Group 4 and Hanlde 5" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD00004EF /end MEASUREMENT
/begin MEASUREMENT Frm_stCANG4_HDL6Rdy "Enable/Ready bit of the message buffer for Group 4 and Hanlde 6" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD00004F0 /end MEASUREMENT
/begin MEASUREMENT Frm_stCANG4_HDL7Rdy "Enable/Ready bit of the message buffer for Group 4 and Hanlde 7" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD00004F1 /end MEASUREMENT
/begin COMPU_METHOD AngleCrS "" RAT_FUNC "%6.4" "deg CrS" COEFFS 0 45.5111111111 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD B_TRUE "" TAB_VERB "%6.3" "" COMPU_TAB_REF B_TRUE /end COMPU_METHOD
/begin COMPU_VTAB B_TRUE "" TAB_VERB 2 0 "----" 1 "TRUE" /end COMPU_VTAB
/begin COMPU_METHOD CrSRev2CrSInc "" RAT_FUNC "%6.4" "-" COEFFS 0 60 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD dez "" RAT_FUNC "%6.2" "" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD DFCDFP_Verb "" TAB_VERB "%2.1" "-" COMPU_TAB_REF DFCDFP_Verb /end COMPU_METHOD
/begin COMPU_VTAB DFCDFP_Verb "" TAB_VERB 528 0 "NoEntry" 1 "DFC_BusDiagBusOffErrPasNodeA" 2 "DFC_BusDiagBusOffErrPasNodeB" 3 "DFC_BusDiagBusOffErrPasNodeC" 4 "DFC_BusDiagBusOffErrPasNodeD" 5 "DFC_BusDiagBusOffNodeA" 6 "DFC_BusDiagBusOffNodeB" 7 "DFC_BusDiagBusOffNodeC" 8 "DFC_BusDiagBusOffNodeD" 9 "DFC_ComCANG1_HDL0TO" 10 "DFC_ComCANG1_HDL10TO" 11 "DFC_ComCANG1_HDL11TO" 12 "DFC_ComCANG1_HDL12TO" 13 "DFC_ComCANG1_HDL13TO" 14 "DFC_ComCANG1_HDL14TO" 15 "DFC_ComCANG1_HDL15TO" 16 "DFC_ComCANG1_HDL16TO" 17 "DFC_ComCANG1_HDL17TO" 18 "DFC_ComCANG1_HDL18TO" 19 "DFC_ComCANG1_HDL19TO" 20 "DFC_ComCANG1_HDL1TO" 21 "DFC_ComCANG1_HDL20TO" 22 "DFC_ComCANG1_HDL21TO" 23 "DFC_ComCANG1_HDL22TO" 24 "DFC_ComCANG1_HDL23TO" 25 "DFC_ComCANG1_HDL24TO" 26 "DFC_ComCANG1_HDL2TO" 27 "DFC_ComCANG1_HDL3TO" 28 "DFC_ComCANG1_HDL4TO" 29 "DFC_ComCANG1_HDL5TO" 30 "DFC_ComCANG1_HDL6TO" 31 "DFC_ComCANG1_HDL7TO" 32 "DFC_ComCANG1_HDL8TO" 33 "DFC_ComCANG1_HDL9TO" 34 "DFC_ComCANG2_HDL0TO" 35 "DFC_ComCANG2_HDL10TO" 36 "DFC_ComCANG2_HDL11TO" 37 "DFC_ComCANG2_HDL12TO" 38 "DFC_ComCANG2_HDL13TO" 39 "DFC_ComCANG2_HDL14TO" 40 "DFC_ComCANG2_HDL15TO" 41 "DFC_ComCANG2_HDL16TO" 42 "DFC_ComCANG2_HDL17TO" 43 "DFC_ComCANG2_HDL18TO" 44 "DFC_ComCANG2_HDL19TO" 45 "DFC_ComCANG2_HDL1TO" 46 "DFC_ComCANG2_HDL20TO" 47 "DFC_ComCANG2_HDL21TO" 48 "DFC_ComCANG2_HDL22TO" 49 "DFC_ComCANG2_HDL23TO" 50 "DFC_ComCANG2_HDL24TO" 51 "DFC_ComCANG2_HDL2TO" 52 "DFC_ComCANG2_HDL3TO" 53 "DFC_ComCANG2_HDL4TO" 54 "DFC_ComCANG2_HDL5TO" 55 "DFC_ComCANG2_HDL6TO" 56 "DFC_ComCANG2_HDL7TO" 57 "DFC_ComCANG2_HDL8TO" 58 "DFC_ComCANG2_HDL9TO" 59 "DFC_ComCANG3_HDL0TO" 60 "DFC_ComCANG3_HDL10TO" 61 "DFC_ComCANG3_HDL11TO" 62 "DFC_ComCANG3_HDL12TO" 63 "DFC_ComCANG3_HDL13TO" 64 "DFC_ComCANG3_HDL14TO" 65 "DFC_ComCANG3_HDL15TO" 66 "DFC_ComCANG3_HDL16TO" 67 "DFC_ComCANG3_HDL17TO" 68 "DFC_ComCANG3_HDL18TO" 69 "DFC_ComCANG3_HDL19TO" 70 "DFC_ComCANG3_HDL1TO" 71 "DFC_ComCANG3_HDL20TO" 72 "DFC_ComCANG3_HDL21TO" 73 "DFC_ComCANG3_HDL22TO" 74 "DFC_ComCANG3_HDL23TO" 75 "DFC_ComCANG3_HDL24TO" 76 "DFC_ComCANG3_HDL2TO" 77 "DFC_ComCANG3_HDL3TO" 78 "DFC_ComCANG3_HDL4TO" 79 "DFC_ComCANG3_HDL5TO" 80 "DFC_ComCANG3_HDL6TO" 81 "DFC_ComCANG3_HDL7TO" 82 "DFC_ComCANG3_HDL8TO" 83 "DFC_ComCANG3_HDL9TO" 84 "DFC_ComCANG4_HDL0TO" 85 "DFC_ComCANG4_HDL10TO" 86 "DFC_ComCANG4_HDL11TO" 87 "DFC_ComCANG4_HDL12TO" 88 "DFC_ComCANG4_HDL13TO" 89 "DFC_ComCANG4_HDL14TO" 90 "DFC_ComCANG4_HDL15TO" 91 "DFC_ComCANG4_HDL16TO" 92 "DFC_ComCANG4_HDL17TO" 93 "DFC_ComCANG4_HDL18TO" 94 "DFC_ComCANG4_HDL19TO" 95 "DFC_ComCANG4_HDL1TO" 96 "DFC_ComCANG4_HDL20TO" 97 "DFC_ComCANG4_HDL21TO" 98 "DFC_ComCANG4_HDL22TO" 99 "DFC_ComCANG4_HDL23TO" 100 "DFC_ComCANG4_HDL24TO" 101 "DFC_ComCANG4_HDL2TO" 102 "DFC_ComCANG4_HDL3TO" 103 "DFC_ComCANG4_HDL4TO" 104 "DFC_ComCANG4_HDL5TO" 105 "DFC_ComCANG4_HDL6TO" 106 "DFC_ComCANG4_HDL7TO" 107 "DFC_ComCANG4_HDL8TO" 108 "DFC_ComCANG4_HDL9TO" 109 "DFC_Cy150SpiCom" 110 "DFC_Cy320SpiCom" 111 "DFC_MonUMaxSupply1" 112 "DFC_MonUMaxSupply2" 113 "DFC_MonUMaxSupply3" 114 "DFC_MonUMinSupply1" 115 "DFC_MonUMinSupply2" 116 "DFC_MonUMinSupply3" 117 "DFC_SSpMon1" 118 "DFC_SSpMon1OV" 119 "DFC_SSpMon1UV" 120 "DFC_SSpMon2" 121 "DFC_SSpMon2OV" 122 "DFC_SSpMon2UV" 123 "DFC_SSpMon3" 124 "DFC_SSpMon3OV" 125 "DFC_SSpMon3UV" 126 "DFC_HDEVK_MIN_0" 127 "DFC_HDEVK_MIN_1" 128 "DFC_HDEVK_NPL_0" 129 "DFC_HDEVK_NPL_1" 130 "DFC_HDEVK_SIG_0" 131 "DFC_HDEVK_SIG_1" 132 "DFC_IgnClPsClOpen0" 133 "DFC_IgnClPsClOpen1" 134 "DFC_IgnClPsClOpen2" 135 "DFC_IgnClPsClOpen3" 136 "DFC_IgnClPsClOpen4" 137 "DFC_IgnClPsClOpen5" 138 "DFC_IgnClPsClOpen6" 139 "DFC_IgnClPsClOpen7" 140 "DFC_IgnClPsClShCir0" 141 "DFC_IgnClPsClShCir1" 142 "DFC_IgnClPsClShCir2" 143 "DFC_IgnClPsClShCir3" 144 "DFC_IgnClPsClShCir4" 145 "DFC_IgnClPsClShCir5" 146 "DFC_IgnClPsClShCir6" 147 "DFC_IgnClPsClShCir7" 148 "DFC_IgnClPsClUnExpt0" 149 "DFC_IgnClPsClUnExpt1" 150 "DFC_IgnClPsClUnExpt2" 151 "DFC_IgnClPsClUnExpt3" 152 "DFC_IgnClPsClUnExpt4" 153 "DFC_IgnClPsClUnExpt5" 154 "DFC_IgnClPsClUnExpt6" 155 "DFC_IgnClPsClUnExpt7" 156 "DFC_IgnClPsDevIdentErr1" 157 "DFC_IgnClPsDevIdentErr2" 158 "DFC_IgnClPsDevInitErr1" 159 "DFC_IgnClPsDevInitErr2" 160 "DFC_IgnClPsDevOscErr1" 161 "DFC_IgnClPsDevOscErr2" 162 "DFC_IgnClPsDevSpiErr1" 163 "DFC_IgnClPsDevSpiErr2" 164 "DFC_IgnClPsOpenLoad0" 165 "DFC_IgnClPsOpenLoad1" 166 "DFC_IgnClPsOpenLoad2" 167 "DFC_IgnClPsOpenLoad3" 168 "DFC_IgnClPsOpenLoad4" 169 "DFC_IgnClPsOpenLoad5" 170 "DFC_IgnClPsOpenLoad6" 171 "DFC_IgnClPsOpenLoad7" 172 "DFC_IgnClPsShCirBatt0" 173 "DFC_IgnClPsShCirBatt1" 174 "DFC_IgnClPsShCirBatt2" 175 "DFC_IgnClPsShCirBatt3" 176 "DFC_IgnClPsShCirBatt4" 177 "DFC_IgnClPsShCirBatt5" 178 "DFC_IgnClPsShCirBatt6" 179 "DFC_IgnClPsShCirBatt7" 180 "DFC_IgnClPsShCirGnd0" 181 "DFC_IgnClPsShCirGnd1" 182 "DFC_IgnClPsShCirGnd2" 183 "DFC_IgnClPsShCirGnd3" 184 "DFC_IgnClPsShCirGnd4" 185 "DFC_IgnClPsShCirGnd5" 186 "DFC_IgnClPsShCirGnd6" 187 "DFC_IgnClPsShCirGnd7" 188 "DFC_KnDetSens1PortAMax" 189 "DFC_KnDetSens1PortAMin" 190 "DFC_KnDetSens1PortBMax" 191 "DFC_KnDetSens1PortBMin" 192 "DFC_KnDetSens2PortAMax" 193 "DFC_KnDetSens2PortAMin" 194 "DFC_KnDetSens2PortBMax" 195 "DFC_KnDetSens2PortBMin" 196 "DFC_KnDetSens3PortAMax" 197 "DFC_KnDetSens3PortAMin" 198 "DFC_KnDetSens3PortBMax" 199 "DFC_KnDetSens3PortBMin" 200 "DFC_KnDetSens4PortAMax" 201 "DFC_KnDetSens4PortAMin" 202 "DFC_KnDetSens4PortBMax" 203 "DFC_KnDetSens4PortBMin" 204 "DFC_MfPsNonPlausible" 205 "DFC_MfPsNonPlausible2" 206 "DFC_MfPsOpenLoad" 207 "DFC_MfPsOpenLoad2" 208 "DFC_MfPsShCirBattLowSide" 209 "DFC_MfPsShCirBattLowSide2" 210 "DFC_MfPsShCirGndLowSide" 211 "DFC_MfPsShCirGndLowSide2" 212 "DFC_DevLibBattUHi" 213 "DFC_DevLibBattULo" 214 "DFC_DSMDummy" 215 "DFC_EEPEraseErr" 216 "DFC_EEPRdErr" 217 "DFC_EEPWrErr" 218 "DFC_EV1max" 219 "DFC_EV1min" 220 "DFC_EV1sig" 221 "DFC_EV2max" 222 "DFC_EV2min" 223 "DFC_EV2sig" 224 "DFC_EV3max" 225 "DFC_EV3min" 226 "DFC_EV3sig" 227 "DFC_EV4max" 228 "DFC_EV4min" 229 "DFC_EV4sig" 230 "DFC_EV5max" 231 "DFC_EV5min" 232 "DFC_EV5sig" 233 "DFC_EV6max" 234 "DFC_EV6min" 235 "DFC_EV6sig" 236 "DFC_EV7max" 237 "DFC_EV7min" 238 "DFC_EV7sig" 239 "DFC_EV8max" 240 "DFC_EV8min" 241 "DFC_EV8sig" 242 "DFC_EpmCaSI1ErrSig" 243 "DFC_EpmCaSI1NoSigMax" 244 "DFC_EpmCaSI1NoSigMin" 245 "DFC_EpmCaSI1OfsErr" 246 "DFC_EpmCaSI2ErrSig" 247 "DFC_EpmCaSI2NoSigMax" 248 "DFC_EpmCaSI2NoSigMin" 249 "DFC_EpmCaSI2OfsErr" 250 "DFC_EpmCaSO1ErrSig" 251 "DFC_EpmCaSO1NoSigMax" 252 "DFC_EpmCaSO1NoSigMin" 253 "DFC_EpmCaSO1OfsErr" 254 "DFC_EpmCaSO2ErrSig" 255 "DFC_EpmCaSO2NoSigMax" 256 "DFC_EpmCaSO2NoSigMin" 257 "DFC_EpmCaSO2OfsErr" 258 "DFC_EpmCrSDGI" 259 "DFC_EpmCrSErrSig" 260 "DFC_EpmCrSNoSig" 261 "DFC_HDEVH_MAX_0" 262 "DFC_HDEVH_MAX_1" 263 "DFC_HDEVH_MAX_2" 264 "DFC_HDEVH_MAX_3" 265 "DFC_HDEVH_MAX_4" 266 "DFC_HDEVH_MAX_5" 267 "DFC_HDEVH_MAX_6" 268 "DFC_HDEVH_MAX_7" 269 "DFC_HDEVH_MIN_0" 270 "DFC_HDEVH_MIN_1" 271 "DFC_HDEVH_MIN_2" 272 "DFC_HDEVH_MIN_3" 273 "DFC_HDEVH_MIN_4" 274 "DFC_HDEVH_MIN_5" 275 "DFC_HDEVH_MIN_6" 276 "DFC_HDEVH_MIN_7" 277 "DFC_HDEVH_NPL_0" 278 "DFC_HDEVH_NPL_1" 279 "DFC_HDEVH_NPL_2" 280 "DFC_HDEVH_NPL_3" 281 "DFC_HDEVH_NPL_4" 282 "DFC_HDEVH_NPL_5" 283 "DFC_HDEVH_NPL_6" 284 "DFC_HDEVH_NPL_7" 285 "DFC_HDEVL_MAX_0" 286 "DFC_HDEVL_MAX_1" 287 "DFC_HDEVL_MAX_2" 288 "DFC_HDEVL_MAX_3" 289 "DFC_HDEVL_MAX_4" 290 "DFC_HDEVL_MAX_5" 291 "DFC_HDEVL_MAX_6" 292 "DFC_HDEVL_MAX_7" 293 "DFC_HDEVL_MIN_0" 294 "DFC_HDEVL_MIN_1" 295 "DFC_HDEVL_MIN_2" 296 "DFC_HDEVL_MIN_3" 297 "DFC_HDEVL_MIN_4" 298 "DFC_HDEVL_MIN_5" 299 "DFC_HDEVL_MIN_6" 300 "DFC_HDEVL_MIN_7" 301 "DFC_HDEVL_NPL_0" 302 "DFC_HDEVL_NPL_1" 303 "DFC_HDEVL_NPL_2" 304 "DFC_HDEVL_NPL_3" 305 "DFC_HDEVL_NPL_4" 306 "DFC_HDEVL_NPL_5" 307 "DFC_HDEVL_NPL_6" 308 "DFC_HDEVL_NPL_7" 309 "DFC_HDEVL_SIG_0" 310 "DFC_HDEVL_SIG_1" 311 "DFC_HDEVL_SIG_2" 312 "DFC_HDEVL_SIG_3" 313 "DFC_HDEVL_SIG_4" 314 "DFC_HDEVL_SIG_5" 315 "DFC_HDEVL_SIG_6" 316 "DFC_HDEVL_SIG_7" 317 "DFC_HSFE2max" 318 "DFC_HSFE2min" 319 "DFC_HSFE2sig" 320 "DFC_HSFEmax" 321 "DFC_HSFEmin" 322 "DFC_HSFEsig" 323 "DFC_HSHE2max" 324 "DFC_HSHE2min" 325 "DFC_HSHE2sig" 326 "DFC_HSHEmax" 327 "DFC_HSHEmin" 328 "DFC_HSHEsig" 329 "DFC_HSVE2max" 330 "DFC_HSVE2maxLSF" 331 "DFC_HSVE2min" 332 "DFC_HSVE2minLSF" 333 "DFC_HSVE2sig" 334 "DFC_HSVE2sigLSF" 335 "DFC_HSVEmax" 336 "DFC_HSVEmaxLSF" 337 "DFC_HSVEmin" 338 "DFC_HSVEminLSF" 339 "DFC_HSVEsig" 340 "DFC_HSVEsigLSF" 341 "DFC_ICLSU2max" 342 "DFC_ICLSU2min" 343 "DFC_ICLSU2npl" 344 "DFC_ICLSU2sig" 345 "DFC_ICLSUmax" 346 "DFC_ICLSUmin" 347 "DFC_ICLSUnpl" 348 "DFC_ICLSUsig" 349 "DFC_LSF2max" 350 "DFC_LSF2min" 351 "DFC_LSF2npl" 352 "DFC_LSF2sig" 353 "DFC_LSFmax" 354 "DFC_LSFmin" 355 "DFC_LSFnpl" 356 "DFC_LSFsig" 357 "DFC_LSH2max" 358 "DFC_LSH2min" 359 "DFC_LSH2npl" 360 "DFC_LSH2sig" 361 "DFC_LSHmax" 362 "DFC_LSHmin" 363 "DFC_LSHnpl" 364 "DFC_LSHsig" 365 "DFC_LSUIA2sig" 366 "DFC_LSUIAsig" 367 "DFC_LSUIP2max" 368 "DFC_LSUIP2npl" 369 "DFC_LSUIP2sig" 370 "DFC_LSUIPmax" 371 "DFC_LSUIPnpl" 372 "DFC_LSUIPsig" 373 "DFC_LSUKS2max" 374 "DFC_LSUKS2min" 375 "DFC_LSUKSmax" 376 "DFC_LSUKSmin" 377 "DFC_LSUUN2sig" 378 "DFC_LSUUNsig" 379 "DFC_LSUVM2sig" 380 "DFC_LSUVMsig" 381 "DFC_LSV2max" 382 "DFC_LSV2min" 383 "DFC_LSV2npl" 384 "DFC_LSV2sig" 385 "DFC_LSVmax" 386 "DFC_LSVmin" 387 "DFC_LSVnpl" 388 "DFC_LSVsig" 389 "DFC_MD00max" 390 "DFC_MD00min" 391 "DFC_MD00npl" 392 "DFC_MD01max" 393 "DFC_MD01min" 394 "DFC_MD01npl" 395 "DFC_MD02max" 396 "DFC_MD02min" 397 "DFC_MD02npl" 398 "DFC_MD03max" 399 "DFC_MD03min" 400 "DFC_MD03npl" 401 "DFC_MD04max" 402 "DFC_MD04min" 403 "DFC_MD04npl" 404 "DFC_MD05max" 405 "DFC_MD05min" 406 "DFC_MD05npl" 407 "DFC_MD06max" 408 "DFC_MD06min" 409 "DFC_MD06npl" 410 "DFC_MD07max" 411 "DFC_MD07min" 412 "DFC_MD07npl" 413 "DFC_MDmax" 414 "DFC_MDmin" 415 "DFC_MDnpl" 416 "DFC_MRlyErlyOpng" 417 "DFC_MRlyStk" 418 "DFC_PLLSUmax" 419 "DFC_PLLSUmin" 420 "DFC_PLLSUnpl" 421 "DFC_PLLSUsig" 422 "DFC_SWReset_0" 423 "DFC_SWReset_1" 424 "DFC_SWReset_2" 425 "DFP_AAA" 426 "DFP_BM" 427 "DFP_DYLSU" 428 "DFP_DYLSU2" 429 "DFP_DZIC1" 430 "DFP_DZIC2" 431 "DFP_DZIF0" 432 "DFP_DZIF1" 433 "DFP_DZIF2" 434 "DFP_DZIF3" 435 "DFP_DZIF4" 436 "DFP_DZIF5" 437 "DFP_DZIF6" 438 "DFP_DZIF7" 439 "DFP_DZKU0" 440 "DFP_DZKU1" 441 "DFP_DZKU2" 442 "DFP_DZKU3" 443 "DFP_DZKU4" 444 "DFP_DZKU5" 445 "DFP_DZKU6" 446 "DFP_DZKU7" 447 "DFP_EV1" 448 "DFP_EV2" 449 "DFP_EV3" 450 "DFP_EV4" 451 "DFP_EV5" 452 "DFP_EV6" 453 "DFP_EV7" 454 "DFP_EV8" 455 "DFP_HSF" 456 "DFP_HSF2" 457 "DFP_HSFE" 458 "DFP_HSFE2" 459 "DFP_HSH" 460 "DFP_HSH2" 461 "DFP_HSHE" 462 "DFP_HSHE2" 463 "DFP_HSV" 464 "DFP_HSV2" 465 "DFP_HSVE" 466 "DFP_HSVE2" 467 "DFP_HSVE2LSF" 468 "DFP_HSVELSF" 469 "DFP_ICLSU" 470 "DFP_ICLSU2" 471 "DFP_LASFK" 472 "DFP_LASFK2" 473 "DFP_LASH" 474 "DFP_LASH2" 475 "DFP_LSF" 476 "DFP_LSF2" 477 "DFP_LSFHV" 478 "DFP_LSFHV2" 479 "DFP_LSFV" 480 "DFP_LSH" 481 "DFP_LSH2" 482 "DFP_LSHV" 483 "DFP_LSUIA" 484 "DFP_LSUIA2" 485 "DFP_LSUIP" 486 "DFP_LSUIP2" 487 "DFP_LSUKS" 488 "DFP_LSUKS2" 489 "DFP_LSUUN" 490 "DFP_LSUUN2" 491 "DFP_LSUVM" 492 "DFP_LSUVM2" 493 "DFP_LSV" 494 "DFP_LSV2" 495 "DFP_MD" 496 "DFP_MD00" 497 "DFP_MD01" 498 "DFP_MD02" 499 "DFP_MD03" 500 "DFP_MD04" 501 "DFP_MD05" 502 "DFP_MD06" 503 "DFP_MD07" 504 "DFP_MSVE" 505 "DFP_MSVE2" 506 "DFP_N" 507 "DFP_NWKW" 508 "DFP_NWKW2" 509 "DFP_NWKWA" 510 "DFP_NWKWA2" 511 "DFP_NWKWE" 512 "DFP_NWKWE2" 513 "DFP_PH" 514 "DFP_PH2" 515 "DFP_PHA" 516 "DFP_PHA2" 517 "DFP_PHE" 518 "DFP_PHE2" 519 "DFP_PLLSU" 520 "DFP_PLLSU2" 521 "DFP_PS1E" 522 "DFP_PS2E" 523 "DFP_PS3E" 524 "DFP_TES" 525 "DFP_ULSU" 526 "DFP_ULSU2" 527 "DFP_ZZZ" DEFAULT_VALUE "---" /end COMPU_VTAB
/begin COMPU_METHOD DFCDSQ_Verb "" TAB_VERB "%2.1" "-" COMPU_TAB_REF DFCDSQ_Verb /end COMPU_METHOD
/begin COMPU_VTAB DFCDSQ_Verb "" TAB_VERB 428 0 "NoInhibit" 1 "DFC_BusDiagBusOffErrPasNodeA" 2 "DFC_BusDiagBusOffErrPasNodeB" 3 "DFC_BusDiagBusOffErrPasNodeC" 4 "DFC_BusDiagBusOffErrPasNodeD" 5 "DFC_BusDiagBusOffNodeA" 6 "DFC_BusDiagBusOffNodeB" 7 "DFC_BusDiagBusOffNodeC" 8 "DFC_BusDiagBusOffNodeD" 9 "DFC_ComCANG1_HDL0TO" 10 "DFC_ComCANG1_HDL10TO" 11 "DFC_ComCANG1_HDL11TO" 12 "DFC_ComCANG1_HDL12TO" 13 "DFC_ComCANG1_HDL13TO" 14 "DFC_ComCANG1_HDL14TO" 15 "DFC_ComCANG1_HDL15TO" 16 "DFC_ComCANG1_HDL16TO" 17 "DFC_ComCANG1_HDL17TO" 18 "DFC_ComCANG1_HDL18TO" 19 "DFC_ComCANG1_HDL19TO" 20 "DFC_ComCANG1_HDL1TO" 21 "DFC_ComCANG1_HDL20TO" 22 "DFC_ComCANG1_HDL21TO" 23 "DFC_ComCANG1_HDL22TO" 24 "DFC_ComCANG1_HDL23TO" 25 "DFC_ComCANG1_HDL24TO" 26 "DFC_ComCANG1_HDL2TO" 27 "DFC_ComCANG1_HDL3TO" 28 "DFC_ComCANG1_HDL4TO" 29 "DFC_ComCANG1_HDL5TO" 30 "DFC_ComCANG1_HDL6TO" 31 "DFC_ComCANG1_HDL7TO" 32 "DFC_ComCANG1_HDL8TO" 33 "DFC_ComCANG1_HDL9TO" 34 "DFC_ComCANG2_HDL0TO" 35 "DFC_ComCANG2_HDL10TO" 36 "DFC_ComCANG2_HDL11TO" 37 "DFC_ComCANG2_HDL12TO" 38 "DFC_ComCANG2_HDL13TO" 39 "DFC_ComCANG2_HDL14TO" 40 "DFC_ComCANG2_HDL15TO" 41 "DFC_ComCANG2_HDL16TO" 42 "DFC_ComCANG2_HDL17TO" 43 "DFC_ComCANG2_HDL18TO" 44 "DFC_ComCANG2_HDL19TO" 45 "DFC_ComCANG2_HDL1TO" 46 "DFC_ComCANG2_HDL20TO" 47 "DFC_ComCANG2_HDL21TO" 48 "DFC_ComCANG2_HDL22TO" 49 "DFC_ComCANG2_HDL23TO" 50 "DFC_ComCANG2_HDL24TO" 51 "DFC_ComCANG2_HDL2TO" 52 "DFC_ComCANG2_HDL3TO" 53 "DFC_ComCANG2_HDL4TO" 54 "DFC_ComCANG2_HDL5TO" 55 "DFC_ComCANG2_HDL6TO" 56 "DFC_ComCANG2_HDL7TO" 57 "DFC_ComCANG2_HDL8TO" 58 "DFC_ComCANG2_HDL9TO" 59 "DFC_ComCANG3_HDL0TO" 60 "DFC_ComCANG3_HDL10TO" 61 "DFC_ComCANG3_HDL11TO" 62 "DFC_ComCANG3_HDL12TO" 63 "DFC_ComCANG3_HDL13TO" 64 "DFC_ComCANG3_HDL14TO" 65 "DFC_ComCANG3_HDL15TO" 66 "DFC_ComCANG3_HDL16TO" 67 "DFC_ComCANG3_HDL17TO" 68 "DFC_ComCANG3_HDL18TO" 69 "DFC_ComCANG3_HDL19TO" 70 "DFC_ComCANG3_HDL1TO" 71 "DFC_ComCANG3_HDL20TO" 72 "DFC_ComCANG3_HDL21TO" 73 "DFC_ComCANG3_HDL22TO" 74 "DFC_ComCANG3_HDL23TO" 75 "DFC_ComCANG3_HDL24TO" 76 "DFC_ComCANG3_HDL2TO" 77 "DFC_ComCANG3_HDL3TO" 78 "DFC_ComCANG3_HDL4TO" 79 "DFC_ComCANG3_HDL5TO" 80 "DFC_ComCANG3_HDL6TO" 81 "DFC_ComCANG3_HDL7TO" 82 "DFC_ComCANG3_HDL8TO" 83 "DFC_ComCANG3_HDL9TO" 84 "DFC_ComCANG4_HDL0TO" 85 "DFC_ComCANG4_HDL10TO" 86 "DFC_ComCANG4_HDL11TO" 87 "DFC_ComCANG4_HDL12TO" 88 "DFC_ComCANG4_HDL13TO" 89 "DFC_ComCANG4_HDL14TO" 90 "DFC_ComCANG4_HDL15TO" 91 "DFC_ComCANG4_HDL16TO" 92 "DFC_ComCANG4_HDL17TO" 93 "DFC_ComCANG4_HDL18TO" 94 "DFC_ComCANG4_HDL19TO" 95 "DFC_ComCANG4_HDL1TO" 96 "DFC_ComCANG4_HDL20TO" 97 "DFC_ComCANG4_HDL21TO" 98 "DFC_ComCANG4_HDL22TO" 99 "DFC_ComCANG4_HDL23TO" 100 "DFC_ComCANG4_HDL24TO" 101 "DFC_ComCANG4_HDL2TO" 102 "DFC_ComCANG4_HDL3TO" 103 "DFC_ComCANG4_HDL4TO" 104 "DFC_ComCANG4_HDL5TO" 105 "DFC_ComCANG4_HDL6TO" 106 "DFC_ComCANG4_HDL7TO" 107 "DFC_ComCANG4_HDL8TO" 108 "DFC_ComCANG4_HDL9TO" 109 "DFC_Cy150SpiCom" 110 "DFC_Cy320SpiCom" 111 "DFC_MonUMaxSupply1" 112 "DFC_MonUMaxSupply2" 113 "DFC_MonUMaxSupply3" 114 "DFC_MonUMinSupply1" 115 "DFC_MonUMinSupply2" 116 "DFC_MonUMinSupply3" 117 "DFC_SSpMon1" 118 "DFC_SSpMon1OV" 119 "DFC_SSpMon1UV" 120 "DFC_SSpMon2" 121 "DFC_SSpMon2OV" 122 "DFC_SSpMon2UV" 123 "DFC_SSpMon3" 124 "DFC_SSpMon3OV" 125 "DFC_SSpMon3UV" 126 "DFC_HDEVK_MIN_0" 127 "DFC_HDEVK_MIN_1" 128 "DFC_HDEVK_NPL_0" 129 "DFC_HDEVK_NPL_1" 130 "DFC_HDEVK_SIG_0" 131 "DFC_HDEVK_SIG_1" 132 "DFC_IgnClPsClOpen0" 133 "DFC_IgnClPsClOpen1" 134 "DFC_IgnClPsClOpen2" 135 "DFC_IgnClPsClOpen3" 136 "DFC_IgnClPsClOpen4" 137 "DFC_IgnClPsClOpen5" 138 "DFC_IgnClPsClOpen6" 139 "DFC_IgnClPsClOpen7" 140 "DFC_IgnClPsClShCir0" 141 "DFC_IgnClPsClShCir1" 142 "DFC_IgnClPsClShCir2" 143 "DFC_IgnClPsClShCir3" 144 "DFC_IgnClPsClShCir4" 145 "DFC_IgnClPsClShCir5" 146 "DFC_IgnClPsClShCir6" 147 "DFC_IgnClPsClShCir7" 148 "DFC_IgnClPsClUnExpt0" 149 "DFC_IgnClPsClUnExpt1" 150 "DFC_IgnClPsClUnExpt2" 151 "DFC_IgnClPsClUnExpt3" 152 "DFC_IgnClPsClUnExpt4" 153 "DFC_IgnClPsClUnExpt5" 154 "DFC_IgnClPsClUnExpt6" 155 "DFC_IgnClPsClUnExpt7" 156 "DFC_IgnClPsDevIdentErr1" 157 "DFC_IgnClPsDevIdentErr2" 158 "DFC_IgnClPsDevInitErr1" 159 "DFC_IgnClPsDevInitErr2" 160 "DFC_IgnClPsDevOscErr1" 161 "DFC_IgnClPsDevOscErr2" 162 "DFC_IgnClPsDevSpiErr1" 163 "DFC_IgnClPsDevSpiErr2" 164 "DFC_IgnClPsOpenLoad0" 165 "DFC_IgnClPsOpenLoad1" 166 "DFC_IgnClPsOpenLoad2" 167 "DFC_IgnClPsOpenLoad3" 168 "DFC_IgnClPsOpenLoad4" 169 "DFC_IgnClPsOpenLoad5" 170 "DFC_IgnClPsOpenLoad6" 171 "DFC_IgnClPsOpenLoad7" 172 "DFC_IgnClPsShCirBatt0" 173 "DFC_IgnClPsShCirBatt1" 174 "DFC_IgnClPsShCirBatt2" 175 "DFC_IgnClPsShCirBatt3" 176 "DFC_IgnClPsShCirBatt4" 177 "DFC_IgnClPsShCirBatt5" 178 "DFC_IgnClPsShCirBatt6" 179 "DFC_IgnClPsShCirBatt7" 180 "DFC_IgnClPsShCirGnd0" 181 "DFC_IgnClPsShCirGnd1" 182 "DFC_IgnClPsShCirGnd2" 183 "DFC_IgnClPsShCirGnd3" 184 "DFC_IgnClPsShCirGnd4" 185 "DFC_IgnClPsShCirGnd5" 186 "DFC_IgnClPsShCirGnd6" 187 "DFC_IgnClPsShCirGnd7" 188 "DFC_KnDetSens1PortAMax" 189 "DFC_KnDetSens1PortAMin" 190 "DFC_KnDetSens1PortBMax" 191 "DFC_KnDetSens1PortBMin" 192 "DFC_KnDetSens2PortAMax" 193 "DFC_KnDetSens2PortAMin" 194 "DFC_KnDetSens2PortBMax" 195 "DFC_KnDetSens2PortBMin" 196 "DFC_KnDetSens3PortAMax" 197 "DFC_KnDetSens3PortAMin" 198 "DFC_KnDetSens3PortBMax" 199 "DFC_KnDetSens3PortBMin" 200 "DFC_KnDetSens4PortAMax" 201 "DFC_KnDetSens4PortAMin" 202 "DFC_KnDetSens4PortBMax" 203 "DFC_KnDetSens4PortBMin" 204 "DFC_MfPsNonPlausible" 205 "DFC_MfPsNonPlausible2" 206 "DFC_MfPsOpenLoad" 207 "DFC_MfPsOpenLoad2" 208 "DFC_MfPsShCirBattLowSide" 209 "DFC_MfPsShCirBattLowSide2" 210 "DFC_MfPsShCirGndLowSide" 211 "DFC_MfPsShCirGndLowSide2" 212 "DFC_DevLibBattUHi" 213 "DFC_DevLibBattULo" 214 "DFC_DSMDummy" 215 "DFC_EEPEraseErr" 216 "DFC_EEPRdErr" 217 "DFC_EEPWrErr" 218 "DFC_EV1max" 219 "DFC_EV1min" 220 "DFC_EV1sig" 221 "DFC_EV2max" 222 "DFC_EV2min" 223 "DFC_EV2sig" 224 "DFC_EV3max" 225 "DFC_EV3min" 226 "DFC_EV3sig" 227 "DFC_EV4max" 228 "DFC_EV4min" 229 "DFC_EV4sig" 230 "DFC_EV5max" 231 "DFC_EV5min" 232 "DFC_EV5sig" 233 "DFC_EV6max" 234 "DFC_EV6min" 235 "DFC_EV6sig" 236 "DFC_EV7max" 237 "DFC_EV7min" 238 "DFC_EV7sig" 239 "DFC_EV8max" 240 "DFC_EV8min" 241 "DFC_EV8sig" 242 "DFC_EpmCaSI1ErrSig" 243 "DFC_EpmCaSI1NoSigMax" 244 "DFC_EpmCaSI1NoSigMin" 245 "DFC_EpmCaSI1OfsErr" 246 "DFC_EpmCaSI2ErrSig" 247 "DFC_EpmCaSI2NoSigMax" 248 "DFC_EpmCaSI2NoSigMin" 249 "DFC_EpmCaSI2OfsErr" 250 "DFC_EpmCaSO1ErrSig" 251 "DFC_EpmCaSO1NoSigMax" 252 "DFC_EpmCaSO1NoSigMin" 253 "DFC_EpmCaSO1OfsErr" 254 "DFC_EpmCaSO2ErrSig" 255 "DFC_EpmCaSO2NoSigMax" 256 "DFC_EpmCaSO2NoSigMin" 257 "DFC_EpmCaSO2OfsErr" 258 "DFC_EpmCrSDGI" 259 "DFC_EpmCrSErrSig" 260 "DFC_EpmCrSNoSig" 261 "DFC_HDEVH_MAX_0" 262 "DFC_HDEVH_MAX_1" 263 "DFC_HDEVH_MAX_2" 264 "DFC_HDEVH_MAX_3" 265 "DFC_HDEVH_MAX_4" 266 "DFC_HDEVH_MAX_5" 267 "DFC_HDEVH_MAX_6" 268 "DFC_HDEVH_MAX_7" 269 "DFC_HDEVH_MIN_0" 270 "DFC_HDEVH_MIN_1" 271 "DFC_HDEVH_MIN_2" 272 "DFC_HDEVH_MIN_3" 273 "DFC_HDEVH_MIN_4" 274 "DFC_HDEVH_MIN_5" 275 "DFC_HDEVH_MIN_6" 276 "DFC_HDEVH_MIN_7" 277 "DFC_HDEVH_NPL_0" 278 "DFC_HDEVH_NPL_1" 279 "DFC_HDEVH_NPL_2" 280 "DFC_HDEVH_NPL_3" 281 "DFC_HDEVH_NPL_4" 282 "DFC_HDEVH_NPL_5" 283 "DFC_HDEVH_NPL_6" 284 "DFC_HDEVH_NPL_7" 285 "DFC_HDEVL_MAX_0" 286 "DFC_HDEVL_MAX_1" 287 "DFC_HDEVL_MAX_2" 288 "DFC_HDEVL_MAX_3" 289 "DFC_HDEVL_MAX_4" 290 "DFC_HDEVL_MAX_5" 291 "DFC_HDEVL_MAX_6" 292 "DFC_HDEVL_MAX_7" 293 "DFC_HDEVL_MIN_0" 294 "DFC_HDEVL_MIN_1" 295 "DFC_HDEVL_MIN_2" 296 "DFC_HDEVL_MIN_3" 297 "DFC_HDEVL_MIN_4" 298 "DFC_HDEVL_MIN_5" 299 "DFC_HDEVL_MIN_6" 300 "DFC_HDEVL_MIN_7" 301 "DFC_HDEVL_NPL_0" 302 "DFC_HDEVL_NPL_1" 303 "DFC_HDEVL_NPL_2" 304 "DFC_HDEVL_NPL_3" 305 "DFC_HDEVL_NPL_4" 306 "DFC_HDEVL_NPL_5" 307 "DFC_HDEVL_NPL_6" 308 "DFC_HDEVL_NPL_7" 309 "DFC_HDEVL_SIG_0" 310 "DFC_HDEVL_SIG_1" 311 "DFC_HDEVL_SIG_2" 312 "DFC_HDEVL_SIG_3" 313 "DFC_HDEVL_SIG_4" 314 "DFC_HDEVL_SIG_5" 315 "DFC_HDEVL_SIG_6" 316 "DFC_HDEVL_SIG_7" 317 "DFC_HSFE2max" 318 "DFC_HSFE2min" 319 "DFC_HSFE2sig" 320 "DFC_HSFEmax" 321 "DFC_HSFEmin" 322 "DFC_HSFEsig" 323 "DFC_HSHE2max" 324 "DFC_HSHE2min" 325 "DFC_HSHE2sig" 326 "DFC_HSHEmax" 327 "DFC_HSHEmin" 328 "DFC_HSHEsig" 329 "DFC_HSVE2max" 330 "DFC_HSVE2maxLSF" 331 "DFC_HSVE2min" 332 "DFC_HSVE2minLSF" 333 "DFC_HSVE2sig" 334 "DFC_HSVE2sigLSF" 335 "DFC_HSVEmax" 336 "DFC_HSVEmaxLSF" 337 "DFC_HSVEmin" 338 "DFC_HSVEminLSF" 339 "DFC_HSVEsig" 340 "DFC_HSVEsigLSF" 341 "DFC_ICLSU2max" 342 "DFC_ICLSU2min" 343 "DFC_ICLSU2npl" 344 "DFC_ICLSU2sig" 345 "DFC_ICLSUmax" 346 "DFC_ICLSUmin" 347 "DFC_ICLSUnpl" 348 "DFC_ICLSUsig" 349 "DFC_LSF2max" 350 "DFC_LSF2min" 351 "DFC_LSF2npl" 352 "DFC_LSF2sig" 353 "DFC_LSFmax" 354 "DFC_LSFmin" 355 "DFC_LSFnpl" 356 "DFC_LSFsig" 357 "DFC_LSH2max" 358 "DFC_LSH2min" 359 "DFC_LSH2npl" 360 "DFC_LSH2sig" 361 "DFC_LSHmax" 362 "DFC_LSHmin" 363 "DFC_LSHnpl" 364 "DFC_LSHsig" 365 "DFC_LSUIA2sig" 366 "DFC_LSUIAsig" 367 "DFC_LSUIP2max" 368 "DFC_LSUIP2npl" 369 "DFC_LSUIP2sig" 370 "DFC_LSUIPmax" 371 "DFC_LSUIPnpl" 372 "DFC_LSUIPsig" 373 "DFC_LSUKS2max" 374 "DFC_LSUKS2min" 375 "DFC_LSUKSmax" 376 "DFC_LSUKSmin" 377 "DFC_LSUUN2sig" 378 "DFC_LSUUNsig" 379 "DFC_LSUVM2sig" 380 "DFC_LSUVMsig" 381 "DFC_LSV2max" 382 "DFC_LSV2min" 383 "DFC_LSV2npl" 384 "DFC_LSV2sig" 385 "DFC_LSVmax" 386 "DFC_LSVmin" 387 "DFC_LSVnpl" 388 "DFC_LSVsig" 389 "DFC_MD00max" 390 "DFC_MD00min" 391 "DFC_MD00npl" 392 "DFC_MD01max" 393 "DFC_MD01min" 394 "DFC_MD01npl" 395 "DFC_MD02max" 396 "DFC_MD02min" 397 "DFC_MD02npl" 398 "DFC_MD03max" 399 "DFC_MD03min" 400 "DFC_MD03npl" 401 "DFC_MD04max" 402 "DFC_MD04min" 403 "DFC_MD04npl" 404 "DFC_MD05max" 405 "DFC_MD05min" 406 "DFC_MD05npl" 407 "DFC_MD06max" 408 "DFC_MD06min" 409 "DFC_MD06npl" 410 "DFC_MD07max" 411 "DFC_MD07min" 412 "DFC_MD07npl" 413 "DFC_MDmax" 414 "DFC_MDmin" 415 "DFC_MDnpl" 416 "DFC_MRlyErlyOpng" 417 "DFC_MRlyStk" 418 "DFC_PLLSUmax" 419 "DFC_PLLSUmin" 420 "DFC_PLLSUnpl" 421 "DFC_PLLSUsig" 422 "DFC_SWReset_0" 423 "DFC_SWReset_1" 424 "DFC_SWReset_2" 425 "DSQ_DSMInhibitAlways" 426 "DSQ_EpmReverseRun" 427 "DSQ_MRly" DEFAULT_VALUE "---" /end COMPU_VTAB
/begin COMPU_METHOD DFC_OneToOne "" RAT_FUNC "%6.2" "-" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD DFES_Mon_Verb "" TAB_VERB "%6.3" "-" COMPU_TAB_REF DFES_Mon_Verb /end COMPU_METHOD
/begin COMPU_VTAB DFES_Mon_Verb "" TAB_VERB 33 0 "-----" 4097 "entry_rejected" 4098 "entry_preempted" 4099 "del_mismatch" 8196 "double entry" 8197 "no hash entry" 8198 "ok no tst - inkonsist" 8199 "ok tsted - inkonsist" 8200 "def tsted - inkonsist" 8201 "Counter exceeds" 8202 "MEM missing" 8203 "Hash 2 empty line" 8204 "retry entry" 8205 "Hash link exceeds" 8453 "invalid hash" 8454 "def no tst - inkonsist" 8457 "DEL Counter Serv ex" 8458 "MEM no Hash" 8461 "min hash line" 8709 "missing hash entry" 8713 "DEL Counter Pend ex" 8714 "Deb ok missing" 8717 "MIS MOD hashkey" 8969 "DEL Counter OBD ex" 8970 "Deb def missing" 8973 "insert line 2 hash" 9226 "order queue blocked cooperative" 9478 "numbr PDTC mismatch" 16399 "pot_sus_ffr" 16655 "used_sus_ffr" 32782 "miss diumpr Fid" 32783 "miss dfc DFP" 32769 "invalid DTR limit" /end COMPU_VTAB
/begin COMPU_METHOD DFES_OneToOne "" RAT_FUNC "%6.2" "-" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD DFES_stCheck_Verb "" TAB_VERB "%6.3" "-" COMPU_TAB_REF DFES_stCheck_Verb /end COMPU_METHOD
/begin COMPU_VTAB DFES_stCheck_Verb "" TAB_VERB 128 0 "OkNoTst" 1 "OkTested" 2 "OkHealed" 3 "OkRstNoTst" 4 "DefectNoTst" 5 "DefectDelay" 6 "Defect" 7 "DefectRstNoTst" 16 "SC_OkNoTst" 17 "SC_OkTested" 18 "SC_OkHealed" 19 "SC_OkRstNoTst" 20 "SC_DefectNoTst" 21 "SC_DefectDelay" 22 "SC_Defect" 23 "SC_DefectRstNoTst" 32 "FC_OkNoTst" 33 "FC_OkTested" 34 "FC_OkHealed" 35 "FC_OkRstNoTst" 36 "FC_DefectNoTst" 37 "FC_DefectDelay" 38 "FC_Defect" 39 "FC_DefectRstNoTst" 48 "FC_SC_OkNoTst" 49 "FC_SC_OkTested" 50 "FC_SC_OkHealed" 51 "FC_SC_OkRstNoTst" 52 "FC_SC_DefectNoTst" 53 "FC_SC_DefectDelay" 54 "FC_SC_Defect" 55 "FC_SC_DefectRstNoTst" 64 "_OkNoTst" 65 "_OkTested" 66 "_OkHealed" 67 "_OkRstNoTst" 68 "_DefectNoTst" 69 "_DefectDelay" 70 "_Defect" 71 "_DefectRstNoTst" 80 "_SC_OkNoTst" 81 "_SC_OkTested" 82 "_SC_OkHealed" 83 "_SC_OkRstNoTst" 84 "_SC_DefectNoTst" 85 "_SC_DefectDelay" 86 "_SC_Defect" 87 "_SC_DefectRstNoTst" 96 "_FC_OkNoTst" 97 "_FC_OkTested" 98 "_FC_OkHealed" 99 "_FC_OkRstNoTst" 100 "_FC_DefectNoTst" 101 "_FC_DefectDelay" 102 "_FC_Defect" 103 "_FC_DefectRstNoTst" 112 "_FC_SC_OkNoTst" 113 "_FC_SC_OkTested" 114 "_FC_SC_OkHealed" 115 "_FC_SC_OkRstNoTst" 116 "_FC_SC_DefectNoTst" 117 "_FC_SC_DefectDelay" 118 "_FC_SC_Defect" 119 "_FC_SC_DefectRstNoTst" 128 "-OkNoTst" 129 "-OkTested" 130 "-OkHealed" 131 "-OkRstNoTst" 132 "-DefectNoTst" 133 "-DefectDelay" 134 "-Defect" 135 "-DefectRstNoTst" 144 "-SC_OkNoTst" 145 "-SC_OkTested" 146 "-SC_OkHealed" 147 "-SC_OkRstNoTst" 148 "-SC_DefectNoTst" 149 "-SC_DefectDelay" 150 "-SC_Defect" 151 "-SC_DefectRstNoTst" 160 "-FC_OkNoTst" 161 "-FC_OkTested" 162 "-FC_OkHealed" 163 "-FC_OkRstNoTst" 164 "-FC_DefectNoTst" 165 "-FC_DefectDelay" 166 "-FC_Defect" 167 "-FC_DefectRstNoTst" 176 "-FC_SC_OkNoTst" 177 "-FC_SC_OkTested" 178 "-FC_SC_OkHealed" 179 "-FC_SC_OkRstNoTst" 180 "-FC_SC_DefectNoTst" 181 "-FC_SC_DefectDelay" 182 "-FC_SC_Defect" 183 "-FC_SC_DefectRstNoTst" 192 "-_OkNoTst" 193 "-_OkTested" 194 "-_OkHealed" 195 "-_OkRstNoTst" 196 "-_DefectNoTst" 197 "-_DefectDelay" 198 "-_Defect" 199 "-_DefectRstNoTst" 208 "-_SC_OkNoTst" 209 "-_SC_OkTested" 210 "-_SC_OkHealed" 211 "-_SC_OkRstNoTst" 212 "-_SC_DefectNoTst" 213 "-_SC_DefectDelay" 214 "-_SC_Defect" 215 "-_SC_DefectRstNoTst" 224 "-_FC_OkNoTst" 225 "-_FC_OkTested" 226 "-_FC_OkHealed" 227 "-_FC_OkRstNoTst" 228 "-_FC_DefectNoTst" 229 "-_FC_DefectDelay" 230 "-_FC_Defect" 231 "-_FC_DefectRstNoTst" 240 "-_FC_SC_OkNoTst" 241 "-_FC_SC_OkTested" 242 "-_FC_SC_OkHealed" 243 "-_FC_SC_OkRstNoTst" 244 "-_FC_SC_DefectNoTst" 245 "-_FC_SC_DefectDelay" 246 "-_FC_SC_Defect" 247 "-_FC_SC_DefectRstNoTst" /end COMPU_VTAB
/begin COMPU_METHOD DFES_stCnt_Verb "" TAB_VERB "%6.3" "-" COMPU_TAB_REF DFES_stCnt_Verb /end COMPU_METHOD
/begin COMPU_VTAB DFES_stCnt_Verb "" TAB_VERB 36 0 "SVS_NONE__MIL_NONE" 1 "SVS_NONE__MIL_HLC_TRG" 2 "SVS_NONE__MIL_HLC_ELAP" 3 "SVS_NONE__MIL_FLC_CNT" 4 "SVS_NONE__MIL_FLC_TIME" 5 "SVS_NONE__MIL_HLC_TIME" 16 "SVS_HLC_TRG__MIL_NONE" 17 "SVS_HLC_TRG__MIL_HLC_TRG" 18 "SVS_HLC_TRG__MIL_HLC_ELAP" 19 "SVS_HLC_TRG__MIL_FLC_CNT" 20 "SVS_HLC_TRG__MIL_FLC_TIME" 21 "SVS_HLC_TRG__MIL_HLC_TIME" 32 "SVS_HLC_ELAP__MIL_NONE" 33 "SVS_HLC_ELAP__MIL_HLC_TRG" 34 "SVS_HLC_ELAP__MIL_HLC_ELAP" 35 "SVS_HLC_ELAP__MIL_FLC_CNT" 36 "SVS_HLC_ELAP__MIL_FLC_TIME" 37 "SVS_HLC_ELAP__MIL_HLC_TIME" 48 "SVS_FLC_CNT__MIL_NONE" 49 "SVS_FLC_CNT__MIL_HLC_TRG" 50 "SVS_FLC_CNT__MIL_HLC_ELAP" 51 "SVS_FLC_CNT__MIL_FLC_CNT" 52 "SVS_FLC_CNT__MIL_FLC_TIME" 53 "SVS_FLC_CNT__MIL_HLC_TIME" 64 "SVS_FLC_TIME__MIL_NONE" 65 "SVS_FLC_TIME__MIL_HLC_TRG" 66 "SVS_FLC_TIME__MIL_HLC_ELAP" 67 "SVS_FLC_TIME__MIL_FLC_CNT" 68 "SVS_FLC_TIME__MIL_FLC_TIME" 69 "SVS_FLC_TIME__MIL_HLC_TIME" 80 "SVS_HLC_TIME__MIL_NONE" 81 "SVS_HLC_TIME__MIL_HLC_TRG" 82 "SVS_HLC_TIME__MIL_HLC_ELAP" 83 "SVS_HLC_TIME__MIL_FLC_CNT" 84 "SVS_HLC_TIME__MIL_FLC_TIME" 85 "SVS_HLC_TIME__MIL_HLC_TIME" /end COMPU_VTAB
/begin COMPU_METHOD DFES_stEntry_Verb "" TAB_VERB "%6.3" "-" COMPU_TAB_REF DFES_stEntry_Verb /end COMPU_METHOD
/begin COMPU_VTAB DFES_stEntry_Verb "" TAB_VERB 240 0 "NoEntry" 1 "Erased" 2 "PrivateTemporary" 3 "SVSOff_FreezeFrameOnly" 4 "SVSOff_DelayActiveDefect" 5 "SVSOff_ServiceNoDefect" 6 "SVSOff_ServiceDefect" 7 "SVSOff_ServiceHistoryDefect" 8 "SVSOff_ServiceHistoryNoDefect" 9 "SVSOff_DelayActiveNoDefect" 10 "SVSOff_PendingDefect" 11 "SVSOff_DebouncedDefect" 12 "SVSOff_HistoryPendingDefect" 13 "SVSOff_HealingNoDefect" 14 "SVSOff_HistoryNoDefect" 16 "DelD_NoEntry" 17 "DelD_Erased" 18 "DelD_PrivateTemporary" 19 "SVSOff_DelD_FreezeFrameOnly" 20 "SVSOff_DelD_DelayActiveDefect" 21 "SVSOff_DelD_ServiceNoDefect" 22 "SVSOff_DelD_ServiceDefect" 23 "SVSOff_DelD_ServiceHistoryDefect" 24 "SVSOff_DelD_ServiceHistoryNoDefect" 25 "SVSOff_DelD_DelayActiveNoDefect" 26 "SVSOff_DelD_PendingDefect" 27 "SVSOff_DelD_DebouncedDefect" 28 "SVSOff_DelD_HistoryPendingDefect" 29 "SVSOff_DelD_HealingNoDefect" 30 "SVSOff_DelD_HistoryNoDefect" 32 "P_NoEntry" 33 "P_Erased" 34 "P_PrivateTemporary" 35 "SVSOff_P_FreezeFrameOnly" 36 "SVSOff_P_DelayActiveDefect" 37 "SVSOff_P_ServiceNoDefect" 38 "SVSOff_P_ServiceDefect" 39 "SVSOff_P_ServiceHistoryDefect" 40 "SVSOff_P_ServiceHistoryNoDefect" 41 "SVSOff_P_DelayActiveNoDefect" 42 "SVSOff_P_PendingDefect" 43 "SVSOff_P_DebouncedDefect" 44 "SVSOff_P_HistoryPendingDefect" 45 "SVSOff_P_HealingNoDefect" 46 "SVSOff_P_HistoryNoDefect" 48 "P_DelD_NoEntry" 49 "P_DelD_Erased" 50 "P_DelD_PrivateTemporary" 51 "SVSOff_P_DelD_FreezeFrameOnly" 52 "SVSOff_P_DelD_DelayActiveDefect" 53 "SVSOff_P_DelD_ServiceNoDefect" 54 "SVSOff_P_DelD_ServiceDefect" 55 "SVSOff_P_DelD_ServiceHistoryDefect" 56 "SVSOff_P_DelD_ServiceHistoryNoDefect" 57 "SVSOff_P_DelD_DelayActiveNoDefect" 58 "SVSOff_P_DelD_PendingDefect" 59 "SVSOff_P_DelD_DebouncedDefect" 60 "SVSOff_P_DelD_HistoryPendingDefect" 61 "SVSOff_P_DelD_HealingNoDefect" 62 "SVSOff_P_DelD_HistoryNoDefect" 64 "PS_NoEntry" 65 "PS_Erased" 66 "PS_PrivateTemporary" 67 "SVSOff_PS_FreezeFrameOnly" 68 "SVSOff_PS_DelayActiveDefect" 69 "SVSOff_PS_ServiceNoDefect" 70 "SVSOff_PS_ServiceDefect" 71 "SVSOff_PS_ServiceHistoryDefect" 72 "SVSOff_PS_ServiceHistoryNoDefect" 73 "SVSOff_PS_DelayActiveNoDefect" 74 "SVSOff_PS_PendingDefect" 75 "SVSOff_PS_DebouncedDefect" 76 "SVSOff_PS_HistoryPendingDefect" 77 "SVSOff_PS_HealingNoDefect" 78 "SVSOff_PS_HistoryNoDefect" 80 "PS_DelD_NoEntry" 81 "PS_DelD_Erased" 82 "PS_DelD_PrivateTemporary" 83 "SVSOff_PS_DelD_FreezeFrameOnly" 84 "SVSOff_PS_DelD_DelayActiveDefect" 85 "SVSOff_PS_DelD_ServiceNoDefect" 86 "SVSOff_PS_DelD_ServiceDefect" 87 "SVSOff_PS_DelD_ServiceHistoryDefect" 88 "SVSOff_PS_DelD_ServiceHistoryNoDefect" 89 "SVSOff_PS_DelD_DelayActiveNoDefect" 90 "SVSOff_PS_DelD_PendingDefect" 91 "SVSOff_PS_DelD_DebouncedDefect" 92 "SVSOff_PS_DelD_HistoryPendingDefect" 93 "SVSOff_PS_DelD_HealingNoDefect" 94 "SVSOff_PS_DelD_HistoryNoDefect" 96 "PS_P_NoEntry" 97 "PS_P_Erased" 98 "PS_P_PrivateTemporary" 99 "SVSOff_PS_P_FreezeFrameOnly" 100 "SVSOff_PS_P_DelayActiveDefect" 101 "SVSOff_PS_P_ServiceNoDefect" 102 "SVSOff_PS_P_ServiceDefect" 103 "SVSOff_PS_P_ServiceHistoryDefect" 104 "SVSOff_PS_P_ServiceHistoryNoDefect" 105 "SVSOff_PS_P_DelayActiveNoDefect" 106 "SVSOff_PS_P_PendingDefect" 107 "SVSOff_PS_P_DebouncedDefect" 108 "SVSOff_PS_P_HistoryPendingDefect" 109 "SVSOff_PS_P_HealingNoDefect" 110 "SVSOff_PS_P_HistoryNoDefect" 112 "PS_P_DelD_NoEntry" 113 "PS_P_DelD_Erased" 114 "PS_P_DelD_PrivateTemporary" 115 "SVSOff_PS_P_DelD_FreezeFrameOnly" 116 "SVSOff_PS_P_DelD_DelayActiveDefect" 117 "SVSOff_PS_P_DelD_ServiceNoDefect" 118 "SVSOff_PS_P_DelD_ServiceDefect" 119 "SVSOff_PS_P_DelD_ServiceHistoryDefect" 120 "SVSOff_PS_P_DelD_ServiceHistoryNoDefect" 121 "SVSOff_PS_P_DelD_DelayActiveNoDefect" 122 "SVSOff_PS_P_DelD_PendingDefect" 123 "SVSOff_PS_P_DelD_DebouncedDefect" 124 "SVSOff_PS_P_DelD_HistoryPendingDefect" 125 "SVSOff_PS_P_DelD_HealingNoDefect" 126 "SVSOff_PS_P_DelD_HistoryNoDefect" 128 "SVSOn_NoEntry" 129 "SVSOn_Erased" 130 "SVSOn_PrivateTemporary" 131 "SVSOn_FreezeFrameOnly" 132 "SVSOn_DelayActiveDefect" 133 "SVSOn_ServiceNoDefect" 134 "SVSOn_ServiceDefect" 135 "SVSOn_ServiceHistoryDefect" 136 "SVSOn_ServiceHistoryNoDefect" 137 "SVSOn_DelayActiveNoDefect" 138 "SVSOn_PendingDefect" 139 "SVSOn_DebouncedDefect" 140 "SVSOn_HistoryPendingDefect" 141 "SVSOn_HealingNoDefect" 142 "SVSOn_HistoryNoDefect" 144 "SVSOn_DelD_NoEntry" 145 "SVSOn_DelD_Erased" 146 "SVSOn_DelD_PrivateTemporary" 147 "SVSOn_DelD_FreezeFrameOnly" 148 "SVSOn_DelD_DelayActiveDefect" 149 "SVSOn_DelD_ServiceNoDefect" 150 "SVSOn_DelD_ServiceDefect" 151 "SVSOn_DelD_ServiceHistoryDefect" 152 "SVSOn_DelD_ServiceHistoryNoDefect" 153 "SVSOn_DelD_DelayActiveNoDefect" 154 "SVSOn_DelD_PendingDefect" 155 "SVSOn_DelD_DebouncedDefect" 156 "SVSOn_DelD_HistoryPendingDefect" 157 "SVSOn_DelD_HealingNoDefect" 158 "SVSOn_DelD_HistoryNoDefect" 160 "SVSOn_P_NoEntry" 161 "SVSOn_P_Erased" 162 "SVSOn_P_PrivateTemporary" 163 "SVSOn_P_FreezeFrameOnly" 164 "SVSOn_P_DelayActiveDefect" 165 "SVSOn_P_ServiceNoDefect" 166 "SVSOn_P_ServiceDefect" 167 "SVSOn_P_ServiceHistoryDefect" 168 "SVSOn_P_ServiceHistoryNoDefect" 169 "SVSOn_P_DelayActiveNoDefect" 170 "SVSOn_P_PendingDefect" 171 "SVSOn_P_DebouncedDefect" 172 "SVSOn_P_HistoryPendingDefect" 173 "SVSOn_P_HealingNoDefect" 174 "SVSOn_P_HistoryNoDefect" 176 "SVSOn_P_DelD_NoEntry" 177 "SVSOn_P_DelD_Erased" 178 "SVSOn_P_DelD_PrivateTemporary" 179 "SVSOn_P_DelD_FreezeFrameOnly" 180 "SVSOn_P_DelD_DelayActiveDefect" 181 "SVSOn_P_DelD_ServiceNoDefect" 182 "SVSOn_P_DelD_ServiceDefect" 183 "SVSOn_P_DelD_ServiceHistoryDefect" 184 "SVSOn_P_DelD_ServiceHistoryNoDefect" 185 "SVSOn_P_DelD_DelayActiveNoDefect" 186 "SVSOn_P_DelD_PendingDefect" 187 "SVSOn_P_DelD_DebouncedDefect" 188 "SVSOn_P_DelD_HistoryPendingDefect" 189 "SVSOn_P_DelD_HealingNoDefect" 190 "SVSOn_P_DelD_HistoryNoDefect" 192 "SVSOn_PS_NoEntry" 193 "SVSOn_PS_Erased" 194 "SVSOn_PS_PrivateTemporary" 195 "SVSOn_PS_FreezeFrameOnly" 196 "SVSOn_PS_DelayActiveDefect" 197 "SVSOn_PS_ServiceNoDefect" 198 "SVSOn_PS_ServiceDefect" 199 "SVSOn_PS_ServiceHistoryDefect" 200 "SVSOn_PS_ServiceHistoryNoDefect" 201 "SVSOn_PS_DelayActiveNoDefect" 202 "SVSOn_PS_PendingDefect" 203 "SVSOn_PS_DebouncedDefect" 204 "SVSOn_PS_HistoryPendingDefect" 205 "SVSOn_PS_HealingNoDefect" 206 "SVSOn_PS_HistoryNoDefect" 208 "SVSOn_PS_DelD_NoEntry" 209 "SVSOn_PS_DelD_Erased" 210 "SVSOn_PS_DelD_PrivateTemporary" 211 "SVSOn_PS_DelD_FreezeFrameOnly" 212 "SVSOn_PS_DelD_DelayActiveDefect" 213 "SVSOn_PS_DelD_ServiceNoDefect" 214 "SVSOn_PS_DelD_ServiceDefect" 215 "SVSOn_PS_DelD_ServiceHistoryDefect" 216 "SVSOn_PS_DelD_ServiceHistoryNoDefect" 217 "SVSOn_PS_DelD_DelayActiveNoDefect" 218 "SVSOn_PS_DelD_PendingDefect" 219 "SVSOn_PS_DelD_DebouncedDefect" 220 "SVSOn_PS_DelD_HistoryPendingDefect" 221 "SVSOn_PS_DelD_HealingNoDefect" 222 "SVSOn_PS_DelD_HistoryNoDefect" 224 "SVSOn_PS_P_NoEntry" 225 "SVSOn_PS_P_Erased" 226 "SVSOn_PS_P_PrivateTemporary" 227 "SVSOn_PS_P_FreezeFrameOnly" 228 "SVSOn_PS_P_DelayActiveDefect" 229 "SVSOn_PS_P_ServiceNoDefect" 230 "SVSOn_PS_P_ServiceDefect" 231 "SVSOn_PS_P_ServiceHistoryDefect" 232 "SVSOn_PS_P_ServiceHistoryNoDefect" 233 "SVSOn_PS_P_DelayActiveNoDefect" 234 "SVSOn_PS_P_PendingDefect" 235 "SVSOn_PS_P_DebouncedDefect" 236 "SVSOn_PS_P_HistoryPendingDefect" 237 "SVSOn_PS_P_HealingNoDefect" 238 "SVSOn_PS_P_HistoryNoDefect" 240 "SVSOn_PS_P_DelD_NoEntry" 241 "SVSOn_PS_P_DelD_Erased" 242 "SVSOn_PS_P_DelD_PrivateTemporary" 243 "SVSOn_PS_P_DelD_FreezeFrameOnly" 244 "SVSOn_PS_P_DelD_DelayActiveDefect" 245 "SVSOn_PS_P_DelD_ServiceNoDefect" 246 "SVSOn_PS_P_DelD_ServiceDefect" 247 "SVSOn_PS_P_DelD_ServiceHistoryDefect" 248 "SVSOn_PS_P_DelD_ServiceHistoryNoDefect" 249 "SVSOn_PS_P_DelD_DelayActiveNoDefect" 250 "SVSOn_PS_P_DelD_PendingDefect" 251 "SVSOn_PS_P_DelD_DebouncedDefect" 252 "SVSOn_PS_P_DelD_HistoryPendingDefect" 253 "SVSOn_PS_P_DelD_HealingNoDefect" 254 "SVSOn_PS_P_DelD_HistoryNoDefect" /end COMPU_VTAB
/begin COMPU_METHOD DSCHED_FIdExcCauseVerb "" TAB_VERB "%2.1" "-" COMPU_TAB_REF DSCHED_FIdExcCauseVerb /end COMPU_METHOD
/begin COMPU_VTAB DSCHED_FIdExcCauseVerb "" TAB_VERB 6 0 "No_exclusion" 1 "FId_InhibitAlways" 2 "FId_CoordTDCAdap" 253 "NO_PRIO" 254 "MODE_IMPOSSIBLE" 255 "NO_RUN" DEFAULT_VALUE "---" /end COMPU_VTAB
/begin COMPU_METHOD DSCHED_StVerb "" TAB_VERB "%6.3" "-" COMPU_TAB_REF DSCHED_StVerb /end COMPU_METHOD
/begin COMPU_VTAB DSCHED_StVerb "" TAB_VERB 64 0 "____________________________" 2 "_____________________RawPerm" 4 "_________________Act________" 6 "_________________Act_RawPerm" 8 "_____________Lck____________" 10 "_____________Lck_____RawPerm" 12 "_____________Lck_Act________" 14 "_____________Lck_Act_RawPerm" 32 "_________Val________________" 34 "_________Val_________RawPerm" 36 "_________Val_____Act________" 38 "_________Val_____Act_RawPerm" 40 "_________Val_Lck____________" 42 "_________Val_Lck_____RawPerm" 44 "_________Val_Lck_Act________" 46 "_________Val_Lck_Act_RawPerm" 64 "____Perm____________________" 66 "____Perm_____________RawPerm" 68 "____Perm_________Act________" 70 "____Perm_________Act_RawPerm" 72 "____Perm_____Lck____________" 74 "____Perm_____Lck_____RawPerm" 76 "____Perm_____Lck_Act________" 78 "____Perm_____Lck_Act_RawPerm" 96 "____Perm_Val________________" 98 "____Perm_Val_________RawPerm" 100 "____Perm_Val_____Act________" 102 "____Perm_Val_____Act_RawPerm" 104 "____Perm_Val_Lck____________" 106 "____Perm_Val_Lck_____RawPerm" 108 "____Perm_Val_Lck_Act________" 110 "____Perm_Val_Lck_Act_RawPerm" 128 "Rdy_________________________" 130 "Rdy__________________RawPerm" 132 "Rdy______________Act________" 134 "Rdy______________Act_RawPerm" 136 "Rdy__________Lck____________" 138 "Rdy__________Lck_____RawPerm" 140 "Rdy__________Lck_Act________" 142 "Rdy__________Lck_Act_RawPerm" 160 "Rdy______Val________________" 162 "Rdy______Val_________RawPerm" 164 "Rdy______Val_____Act________" 166 "Rdy______Val_____Act_RawPerm" 168 "Rdy______Val_Lck____________" 170 "Rdy______Val_Lck_____RawPerm" 172 "Rdy______Val_Lck_Act________" 174 "Rdy______Val_Lck_Act_RawPerm" 192 "Rdy_Perm____________________" 194 "Rdy_Perm_____________RawPerm" 196 "Rdy_Perm_________Act________" 198 "Rdy_Perm_________Act_RawPerm" 200 "Rdy_Perm_____Lck____________" 202 "Rdy_Perm_____Lck_____RawPerm" 204 "Rdy_Perm_____Lck_Act________" 206 "Rdy_Perm_____Lck_Act_RawPerm" 224 "Rdy_Perm_Val________________" 226 "Rdy_Perm_Val_________RawPerm" 228 "Rdy_Perm_Val_____Act________" 230 "Rdy_Perm_Val_____Act_RawPerm" 232 "Rdy_Perm_Val_Lck____________" 234 "Rdy_Perm_Val_Lck_____RawPerm" 236 "Rdy_Perm_Val_Lck_Act________" 238 "Rdy_Perm_Val_Lck_Act_RawPerm" /end COMPU_VTAB
/begin COMPU_METHOD DSCHED_Time200ms "" RAT_FUNC "%6.3" "s" COEFFS 0 5 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD DSMDUR_10m_Counter "" RAT_FUNC "%6.4" "km" COEFFS 0 100 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD DSMDur_StDispl_Verb "" TAB_VERB "%6.3" "-" COMPU_TAB_REF DSMDur_StDispl_Verb /end COMPU_METHOD
/begin COMPU_VTAB DSMDur_StDispl_Verb "" TAB_VERB 3 0 "NotEnabled" 1 "CountingEnabled" 2 "ResetCondition" /end COMPU_VTAB
/begin COMPU_METHOD DSMRdy_OneToOne "" RAT_FUNC "%6.2" "-" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD Eeebd_EeeStates_Verb "" TAB_VERB "%6.3" "" COMPU_TAB_REF Eeebd_EeeStates_Verb /end COMPU_METHOD
/begin COMPU_VTAB Eeebd_EeeStates_Verb "" TAB_VERB 4 0 "EEEBD_EEE_NORMALRUN" 1 "EEEBD_EEE_FIRSTINIT" 2 "EEEBD_EEE_SECTORCHANGE" 3 "EEEBD_EEE_MIGRATION" /end COMPU_VTAB
/begin COMPU_METHOD Eep_MainStates_Verb "" TAB_VERB "%6.3" "" COMPU_TAB_REF Eep_MainStates_Verb /end COMPU_METHOD
/begin COMPU_VTAB Eep_MainStates_Verb "" TAB_VERB 13 0 "EEP_INI_RUN" 1 "EEP_SHUTDWN_RUN" 2 "EEP_NORMAL_RUN" 3 "EEP_BEGPD_REQUEST" 4 "EEP_BEGPD_RUN" 5 "EEP_ENDPD_REQUEST" 6 "EEP_ENDPD_RUN" 7 "EEP_PREDRV_REQUEST" 8 "EEP_PREDRV_RUN" 9 "EEP_FIRSTINIT_INI" 10 "EEP_RAM_INI" 11 "EEP_ENVRAM_INI" 12 "EEP_REINIT_INI" /end COMPU_VTAB
/begin COMPU_METHOD Eep_PostDrvState_Verb "" TAB_VERB "%6.3" "" COMPU_TAB_REF Eep_PostDrvState_Verb /end COMPU_METHOD
/begin COMPU_VTAB Eep_PostDrvState_Verb "" TAB_VERB 5 0 "EEP_POSTDRV_INI" 1 "EEP_POSTDRV_SEARCHBLKIDX" 2 "EEP_POEEP_POSTDRV_SAVEBLK" 3 "EEP_POSTDRV_SAVEBLK_PENDING" 4 "EEP_POSTDRV_WAIT" /end COMPU_VTAB
/begin COMPU_METHOD EngN "" RAT_FUNC "%6.3" "rpm" COEFFS 0 2 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD EngNGrd "" RAT_FUNC "%6.3" "rpm/s" COEFFS 0 2 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD EngN_LRes "" RAT_FUNC "%6.1" "rpm" COEFFS 0 0.025 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD EpmBCa_FacTstInj "" RAT_FUNC "%6.5" "-" COEFFS 0 1000 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD EpmBCa_stTstInj_State_t "" TAB_VERB "%6.3" "" COMPU_TAB_REF EpmBCa_stTstInj_State_t /end COMPU_METHOD
/begin COMPU_VTAB EpmBCa_stTstInj_State_t "" TAB_VERB 6 0 "EPMBCA_STVOID" 1 "EPMBCA_STINJ" 2 "EPMBCA_STWAITCALC" 3 "EPMBCA_STCALC" 4 "EPMBCA_STNOSYNC" 5 "EPMBCA_STSYNC" /end COMPU_VTAB
/begin COMPU_METHOD EpmCaS_stAdap_State "" TAB_VERB "%6.3" "" COMPU_TAB_REF EpmCaS_stAdap_State /end COMPU_METHOD
/begin COMPU_VTAB EpmCaS_stAdap_State "" TAB_VERB 5 0 "EPMCAS_STNOADAP" 1 "EPMCAS_STERRADAP" 2 "EPMCAS_STADAP" 3 "EPMCAS_STADAPSTOP" 4 "EPMCAS_STFULLADAP" /end COMPU_VTAB
/begin COMPU_METHOD EpmCaS_stAgPhaShift_t "" TAB_VERB "%6.3" "" COMPU_TAB_REF EpmCaS_stAgPhaShift_t /end COMPU_METHOD
/begin COMPU_VTAB EpmCaS_stAgPhaShift_t "" TAB_VERB 4 0 "EPMCAS_STAGINVALID" 1 "EPMCAS_STAGFROZEN" 2 "EPMCAS_STAGLIMITED" 3 "EPMCAS_STAGVALID" /end COMPU_VTAB
/begin COMPU_METHOD EpmCaS_stDiagErr_t "" TAB_VERB "%6.3" "" COMPU_TAB_REF EpmCaS_stDiagErr_t /end COMPU_METHOD
/begin COMPU_VTAB EpmCaS_stDiagErr_t "" TAB_VERB 4 0 "EPMCAS_DIAG_AMBI" 1 "EPMCAS_DIAG_OK" 2 "EPMCAS_DIAG_NOSIG" 3 "EPMCAS_DIAG_ERRSIG" /end COMPU_VTAB
/begin COMPU_METHOD EpmCaS_stDiag_t "" TAB_VERB "%6.3" "" COMPU_TAB_REF EpmCaS_stDiag_t /end COMPU_METHOD
/begin COMPU_VTAB EpmCaS_stDiag_t "" TAB_VERB 5 0 "EPMCAS_DIAG_OFF" 1 "EPMCAS_DIAG_PATMAT" 2 "EPMCAS_DIAG_CTEDGE" 3 "EPMCAS_DIAG_NO_SIG" 4 "EPMCAS_DIAG_STOP" /end COMPU_VTAB
/begin COMPU_METHOD EpmCaS_stOfsErr_Val "" TAB_VERB "%6.3" "" COMPU_TAB_REF EpmCaS_stOfsErr_Val /end COMPU_METHOD
/begin COMPU_VTAB EpmCaS_stOfsErr_Val "" TAB_VERB 6 0 "EPMCAS_OFS_AMBI" 1 "EPMCAS_OFS_NOEQUI_EDGE" 2 "EPMCAS_OFS_LOWEQUI_EDGE" 3 "EPMCAS_OFS_NOREFPOS" 4 "EPMCAS_OFS_EXCEED" 5 "EPMCAS_OFS_OK" /end COMPU_VTAB
/begin COMPU_METHOD EpmCas_stOfs_State "" TAB_VERB "%6.3" "" COMPU_TAB_REF EpmCas_stOfs_State /end COMPU_METHOD
/begin COMPU_VTAB EpmCas_stOfs_State "" TAB_VERB 2 0 "EPMCAS_OFS_WAITSEG" 1 "EPMCAS_OFS_SEGCALC" /end COMPU_VTAB
/begin COMPU_METHOD EpmCaS_stphiDiffLim_t "" TAB_VERB "%6.3" "" COMPU_TAB_REF EpmCaS_stphiDiffLim_t /end COMPU_METHOD
/begin COMPU_VTAB EpmCaS_stphiDiffLim_t "" TAB_VERB 8 0 "RET_OK" 1 "RET_SYNADP" 2 "RET_PERM" 3 "RET_PREP" 4 "RET_GETLST" 5 "RET_GETCUR" 6 "RET_NOVALIDEDGE" 8 "RET_MECHLIM" /end COMPU_VTAB
/begin COMPU_METHOD EpmCrS_DiagResult_State "" TAB_VERB "%6.3" "" COMPU_TAB_REF EpmCrS_DiagResult_State /end COMPU_METHOD
/begin COMPU_VTAB EpmCrS_DiagResult_State "" TAB_VERB 5 0 "EPMCRS_DIAG_PENDING" 1 "EPMCRS_DIAG_DEBHEAL" 2 "EPMCRS_DIAG_HEAL" 3 "EPMCRS_DIAG_DEBSET" 4 "EPMCRS_DIAG_SET" /end COMPU_VTAB
/begin COMPU_METHOD EpmCrS_Diag_State "" TAB_VERB "%6.3" "" COMPU_TAB_REF EpmCrS_Diag_State /end COMPU_METHOD
/begin COMPU_VTAB EpmCrS_Diag_State "" TAB_VERB 2 0 "EPMCRS_DIAG_OFF" 1 "EPMCRS_DIAG_ON" /end COMPU_VTAB
/begin COMPU_METHOD EpmHCrS_stSigMode_State_t "" TAB_VERB "%6.3" "" COMPU_TAB_REF EpmHCrS_stSigMode_State_t /end COMPU_METHOD
/begin COMPU_VTAB EpmHCrS_stSigMode_State_t "" TAB_VERB 12 0 "RESET" 1 "HALT" 2 "WAITSIG" 3 "IGNTIME" 4 "IGNFRSTEDGE" 5 "IGNEDGE" 6 "WAITGAP" 7 "GAPFOUND" 8 "TIMERMODE" 9 "DISBLNEWSYNC" 10 "DLY" 11 "KEEPDGISYNC" /end COMPU_VTAB
/begin COMPU_METHOD EpmRRS_stRotDir_t "" TAB_VERB "%6.3" "" COMPU_TAB_REF EpmRRS_stRotDir_t /end COMPU_METHOD
/begin COMPU_VTAB EpmRRS_stRotDir_t "" TAB_VERB 3 0 "AMBI" 1 "FORWARD" 2 "BACKWARD" /end COMPU_VTAB
/begin COMPU_METHOD EpmSeq_numInt_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF EpmSeq_numInt_Compu /end COMPU_METHOD
/begin COMPU_VTAB EpmSeq_numInt_Compu "" TAB_VERB 9 0 "S_0" 1 "S_1" 2 "S_0_FIRST" 3 "S_1_FIRST" 6 "S_0_FIRST_START" 7 "S_1_FIRST_START" 8 "S_EPM" 16 "S_INI" 32 "S_0_H" /end COMPU_VTAB
/begin COMPU_METHOD EpmSeq_stInt_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF EpmSeq_stInt_Compu /end COMPU_METHOD
/begin COMPU_VTAB EpmSeq_stInt_Compu "" TAB_VERB 6 0 "ST_S_0" 1 "ST_S_1" 4 "ST_S_0_START" 5 "ST_S_1_START" 8 "ST_EPM" 32 "ST_S_0_H" /end COMPU_VTAB
/begin COMPU_METHOD EpmSyn_EdgeFailTypes "" TAB_VERB "%6.3" "" COMPU_TAB_REF EpmSyn_EdgeFailTypes /end COMPU_METHOD
/begin COMPU_VTAB EpmSyn_EdgeFailTypes "" TAB_VERB 3 0 "EPMSYN_EDGE_OK" 1 "EPMSYN_EDGE_EARLY" 2 "EPMSYN_EDGE_LATE" /end COMPU_VTAB
/begin COMPU_METHOD EpmSyn_stCaSEvalComp "" TAB_VERB "%6.3" "" COMPU_TAB_REF EpmSyn_stCaSEvalComp /end COMPU_METHOD
/begin COMPU_VTAB EpmSyn_stCaSEvalComp "" TAB_VERB 5 0 "NO_CASPOS" 1 "SEARCH_CASPOS" 2 "VERIFY_CASPOS" 3 "SWTOFF_CASPOS" 4 "EVAL_CASPOS" /end COMPU_VTAB
/begin COMPU_METHOD EpmSyn_stCaSPosComp "" TAB_VERB "%6.3" "" COMPU_TAB_REF EpmSyn_stCaSPosComp /end COMPU_METHOD
/begin COMPU_VTAB EpmSyn_stCaSPosComp "" TAB_VERB 9 0 "EPMSYN_CASPOS_NOTVALID" 1 "EPMSYN_SIGTAB_NOUPDATE" 2 "EPMSYN_SIGTAB_AMBI" 5 "EPMSYN_CASPOS_VALID" 10 "EPMSYN_WRONG_SEG_LEN" 11 "EPMSYN_SIGTAB_END" 12 "EPMSYN_SIGTAB_SEQ" 13 "EPMSYN_EXCEED_TOLC" 20 "EPMSYN_CASPOS_SWTOFF" /end COMPU_VTAB
/begin COMPU_METHOD EpmSyn_stCrSPos_State_t "" TAB_VERB "%6.3" "" COMPU_TAB_REF EpmSyn_stCrSPos_State_t /end COMPU_METHOD
/begin COMPU_VTAB EpmSyn_stCrSPos_State_t "" TAB_VERB 4 0 "EPMSYN_NO_SYNC" 1 "EPMSYN_CRS_SYNC" 2 "EPMSYN_CAS_SYNC" 3 "EPMSYN_FULL_SYNC" /end COMPU_VTAB
/begin COMPU_METHOD Epm_stCmbTestReq_State_t "" TAB_VERB "%6.3" "" COMPU_TAB_REF Epm_stCmbTestReq_State_t /end COMPU_METHOD
/begin COMPU_VTAB Epm_stCmbTestReq_State_t "" TAB_VERB 2 0 "EPM_NO_CMBTEST" 10 "EPM_CMBTEST" /end COMPU_VTAB
/begin COMPU_METHOD Epm_stOpMode_State_t "" TAB_VERB "%6.3" "" COMPU_TAB_REF Epm_stOpMode_State_t /end COMPU_METHOD
/begin COMPU_VTAB Epm_stOpMode_State_t "" TAB_VERB 8 1 "EPM_MODE_WAIT" 5 "EPM_MODE_LOCKRESYNC" 20 "EPM_MODE_ALE" 33 "EPM_MODE_VERIFY" 36 "EPM_MODE_VERIFY_EXT" 38 "EPM_MODE_BACKUP_CAS" 48 "EPM_MODE_OK" 60 "EPM_MODE_BACKUP_CRS" /end COMPU_VTAB
/begin COMPU_METHOD Epm_stSpd_t "" TAB_VERB "%6.3" "" COMPU_TAB_REF Epm_stSpd_t /end COMPU_METHOD
/begin COMPU_VTAB Epm_stSpd_t "" TAB_VERB 5 0 "EPM_SPD_CRS" 1 "EPM_SPD_HOLD" 2 "EPM_SPD_ZERO" 3 "EPM_SPD_CAS" 4 "EPM_SPD_BACKUP" /end COMPU_VTAB
/begin COMPU_METHOD Epm_stSync_State_t "" TAB_VERB "%6.3" "" COMPU_TAB_REF Epm_stSync_State_t /end COMPU_METHOD
/begin COMPU_VTAB Epm_stSync_State_t "" TAB_VERB 5 0 "EPM_NO_SYNC" 10 "EPM_ALE_SYNC" 20 "EPM_CAS_SYNC" 21 "EPM_DIRSTALE_SYNC" 30 "EPM_FULL_SYNC" /end COMPU_VTAB
/begin COMPU_METHOD fak_sw_b1 "" RAT_FUNC "%7.6" "-" COEFFS 0 65536 0 0 0 2 /end COMPU_METHOD
/begin COMPU_METHOD fak_uw_b2 "" RAT_FUNC "%7.6" "-" COEFFS 0 65536 0 0 0 2 /end COMPU_METHOD
/begin COMPU_METHOD GptaClc6_ti_COMPU "" RAT_FUNC "%6.3" "us" COEFFS 0 2.5 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD kw_q0p1 "" RAT_FUNC "%6.3" "Grad KW" COEFFS 0 10 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD Length "" RAT_FUNC "%6.2" "m" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD m_q0p0peri4 "" RAT_FUNC "%6.4" "g" COEFFS 0 45 0 0 0 2 /end COMPU_METHOD
/begin COMPU_METHOD nmot_sw_q0p25 "" RAT_FUNC "%6.3" "1/min" COEFFS 0 1 0 0 0 0.25 /end COMPU_METHOD
/begin COMPU_METHOD OneToOne "" RAT_FUNC "%6.2" "No Unit" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD OneToOne_us "" RAT_FUNC "%6.2" "us" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD Per_Dur "" RAT_FUNC "%6.2" "usec" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD Prc "" RAT_FUNC "%6.4" "%" COEFFS 0 81.92 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD Pres_hPa "" RAT_FUNC "%6.2" "hPa" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD RevCnt "" RAT_FUNC "%6.4" "-" COEFFS 0 16 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD spg_q0p00488 "" RAT_FUNC "%6.4" "V" COEFFS 0 1024 0 0 0 5 /end COMPU_METHOD
/begin COMPU_METHOD spg_q4p88Em4 "" RAT_FUNC "%6.5" "V" COEFFS 0 2048 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD spg_uw_q0p00488_o1 "" RAT_FUNC "%6.3" "V" COEFFS 0 1024 1024 0 0 5 /end COMPU_METHOD
/begin COMPU_METHOD SY_IGNCHN4_Compu "" RAT_FUNC "%6.2" "" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD SY_IGNCHN5_Compu "" RAT_FUNC "%6.2" "" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD SY_IGNCHN6_Compu "" RAT_FUNC "%6.2" "" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD SY_IGNCHN7_Compu "" RAT_FUNC "%6.2" "" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD SY_IGNCHN8_Compu "" RAT_FUNC "%6.2" "" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD SY_IGNCHN9_Compu "" RAT_FUNC "%6.2" "" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD SY_IUMPR_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF SY_IUMPR_Compu /end COMPU_METHOD
/begin COMPU_VTAB SY_IUMPR_Compu "" TAB_VERB 2 0 "keine Auswetung der IUMPR" 1 "Auswertung der IUMPR" /end COMPU_VTAB
/begin COMPU_METHOD SY_KS1_Compu "" RAT_FUNC "%6.2" "" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD SY_KS2_Compu "" RAT_FUNC "%6.2" "" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD SY_KS3_Compu "" RAT_FUNC "%6.2" "" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD SY_KS4_Compu "" RAT_FUNC "%6.2" "" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD SY_KSENCHN_Compu "" RAT_FUNC "%6.2" "" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD SY_KSENFLT_Compu "" RAT_FUNC "%6.2" "" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD SY_KSZA_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF SY_KSZA_Compu /end COMPU_METHOD
/begin COMPU_VTAB SY_KSZA_Compu "" TAB_VERB 5 0 "number of knock sensors is 0" 1 "number of knock sensors is 1" 2 "number of knock sensors is 2" 3 "number of knock sensors is 3" 4 "number of knock sensors is 4" /end COMPU_VTAB
/begin COMPU_METHOD SY_KTIGNBI_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF SY_KTIGNBI_Compu /end COMPU_METHOD
/begin COMPU_VTAB SY_KTIGNBI_Compu "" TAB_VERB 2 0 "False" 1 "True" /end COMPU_VTAB
/begin COMPU_METHOD SY_KT_Compu "" RAT_FUNC "%6.2" "" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD SY_LSFHV_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF SY_LSFHV_Compu /end COMPU_METHOD
/begin COMPU_VTAB SY_LSFHV_Compu "" TAB_VERB 2 0 "keine Diag.vertauschte Sonden hinter F/H-Kat" 1 "Diagn. vertauschte Sonden hinter Front/Hauptkat" /end COMPU_VTAB
/begin COMPU_METHOD SY_LSFSTA_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF SY_LSFSTA_Compu /end COMPU_METHOD
/begin COMPU_VTAB SY_LSFSTA_Compu "" TAB_VERB 2 0 "False" 1 "True" /end COMPU_VTAB
/begin COMPU_METHOD SY_LSFV_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF SY_LSFV_Compu /end COMPU_METHOD
/begin COMPU_VTAB SY_LSFV_Compu "" TAB_VERB 2 0 "keine Diag.vertauschte Sonden hinter FrontKat" 1 "Diagnose vertauschte Sonden hinter FrontKat" /end COMPU_VTAB
/begin COMPU_METHOD SY_LSHSTA_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF SY_LSHSTA_Compu /end COMPU_METHOD
/begin COMPU_VTAB SY_LSHSTA_Compu "" TAB_VERB 2 0 "False" 1 "True" /end COMPU_VTAB
/begin COMPU_METHOD SY_LSHV_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF SY_LSHV_Compu /end COMPU_METHOD
/begin COMPU_VTAB SY_LSHV_Compu "" TAB_VERB 2 0 "keine vertauschte Sonde hinter Kat im System" 1 "vertauschte Sonde hinter Kat im System vorhanden" /end COMPU_VTAB
/begin COMPU_METHOD SY_LSUGR_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF SY_LSUGR_Compu /end COMPU_METHOD
/begin COMPU_VTAB SY_LSUGR_Compu "" TAB_VERB 2 0 "keine LSU mit gepumpter Referenz verbaut" 1 "LSU mit gepumpter Referenz verbaut" /end COMPU_VTAB
/begin COMPU_METHOD SY_LSUIKR2_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF SY_LSUIKR2_Compu /end COMPU_METHOD
/begin COMPU_VTAB SY_LSUIKR2_Compu "" TAB_VERB 2 0 "keine LSU im Abgaskrümmer Bank2 vorhanden" 1 "LSU im Abgaskrümmer Bank2 vorhanden" /end COMPU_VTAB
/begin COMPU_METHOD SY_LSUIKR_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF SY_LSUIKR_Compu /end COMPU_METHOD
/begin COMPU_VTAB SY_LSUIKR_Compu "" TAB_VERB 2 0 "keine LSU im Abgaskrümmer vorhanden" 1 "LSU im Abgaskrümmer vorhanden" /end COMPU_VTAB
/begin COMPU_METHOD SY_LSUMRS_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF SY_LSUMRS_Compu /end COMPU_METHOD
/begin COMPU_VTAB SY_LSUMRS_Compu "" TAB_VERB 2 0 "keine %LSUMRS vorhanden" 1 "%LSUMRS vorhanden" /end COMPU_VTAB
/begin COMPU_METHOD SY_LSUSTA_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF SY_LSUSTA_Compu /end COMPU_METHOD
/begin COMPU_VTAB SY_LSUSTA_Compu "" TAB_VERB 2 0 "False" 1 "True" /end COMPU_VTAB
/begin COMPU_METHOD SY_LSVSTA_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF SY_LSVSTA_Compu /end COMPU_METHOD
/begin COMPU_VTAB SY_LSVSTA_Compu "" TAB_VERB 2 0 "False" 1 "True" /end COMPU_VTAB
/begin COMPU_METHOD SY_LSVV_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF SY_LSVV_Compu /end COMPU_METHOD
/begin COMPU_VTAB SY_LSVV_Compu "" TAB_VERB 2 0 "keine Diag.vertauschte Sonden vor Vorkat" 1 "Diagnose vertauschte Sonden vor Vorkat vorhanden" /end COMPU_VTAB
/begin COMPU_METHOD SY_LUSRKR_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF SY_LUSRKR_Compu /end COMPU_METHOD
/begin COMPU_VTAB SY_LUSRKR_Compu "" TAB_VERB 3 0 "no Scavenging" 1 "Scavenging with Inlet Cam Phasing" 2 "Scavenging with Inlet and Exhaust Cam Phasing" /end COMPU_VTAB
/begin COMPU_METHOD SY_MDI_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF SY_MDI_Compu /end COMPU_METHOD
/begin COMPU_VTAB SY_MDI_Compu "" TAB_VERB 2 0 "False" 1 "True" /end COMPU_VTAB
/begin COMPU_METHOD SY_MSVKOMP_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF SY_MSVKOMP_Compu /end COMPU_METHOD
/begin COMPU_VTAB SY_MSVKOMP_Compu "" TAB_VERB 7 0 "MSV-Ansteuerung Förderenderegelung, z.B. HDP2" 1 "MSV-Ansteuerung Förderbeginnregelung, z.B. Hitachi" 2 "MSV_DBCTR_PWM" 3 "MSV_SAC" 4 "MSV_Hitachi_Generation3" 5 "MSV_Hitachi_Generation1" 6 "MSV_Hitachi_RB" /end COMPU_VTAB
/begin COMPU_METHOD SY_MSVRCUR_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF SY_MSVRCUR_Compu /end COMPU_METHOD
/begin COMPU_VTAB SY_MSVRCUR_Compu "" TAB_VERB 2 0 "DISABLE" 1 "ENABLE (only Bosch HDP)" /end COMPU_VTAB
/begin COMPU_METHOD SY_MXAVM_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF SY_MXAVM_Compu /end COMPU_METHOD
/begin COMPU_VTAB SY_MXAVM_Compu "" TAB_VERB 2 0 "False" 1 "True" /end COMPU_VTAB
/begin COMPU_METHOD SY_NG_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF SY_NG_Compu /end COMPU_METHOD
/begin COMPU_VTAB SY_NG_Compu "" TAB_VERB 4 0 "SY_NG_0" 1 "SY_NG_1" 2 "SY_NG_2" 3 "SY_NG_3" /end COMPU_VTAB
/begin COMPU_METHOD SY_NLZOFF_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF SY_NLZOFF_Compu /end COMPU_METHOD
/begin COMPU_VTAB SY_NLZOFF_Compu "" TAB_VERB 2 0 "false" 1 "true" /end COMPU_VTAB
/begin COMPU_METHOD SY_NWGA2_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF SY_NWGA2_Compu /end COMPU_METHOD
/begin COMPU_VTAB SY_NWGA2_Compu "" TAB_VERB 5 0 "kein Phasengeber auf Nockenwelle verbaut" 1 "Phasengeber 1 auf Nockenwelle Auslass 2" 2 "Phasengeber 2 auf Nockenwelle Auslass 2" 3 "Phasengeber 3 auf Nockenwelle Auslass 2" 4 "Phasengeber 4 auf Nockenwelle Auslass 2" /end COMPU_VTAB
/begin COMPU_METHOD SY_NWGA_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF SY_NWGA_Compu /end COMPU_METHOD
/begin COMPU_VTAB SY_NWGA_Compu "" TAB_VERB 5 0 "kein Phasengeber auf Nockenwelle verbaut" 1 "Phasengeber 1 auf Nockenwelle Auslass" 2 "Phasengeber 2 auf Nockenwelle Auslass" 3 "Phasengeber 3 auf Nockenwelle Auslass" 4 "Phasengeber 4 auf Nockenwelle Auslass" /end COMPU_VTAB
/begin COMPU_METHOD SY_NWGE2_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF SY_NWGE2_Compu /end COMPU_METHOD
/begin COMPU_VTAB SY_NWGE2_Compu "" TAB_VERB 5 0 "kein Phasengeber auf Nockenwelle verbaut" 1 "Phasengeber 1 auf Nockenwelle Einlass 2" 2 "Phasengeber 2 auf Nockenwelle Einlass 2" 3 "Phasengeber 3 auf Nockenwelle Einlass 2" 4 "Phasengeber 4 auf Nockenwelle Einlass 2" /end COMPU_VTAB
/begin COMPU_METHOD SY_NWGE_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF SY_NWGE_Compu /end COMPU_METHOD
/begin COMPU_VTAB SY_NWGE_Compu "" TAB_VERB 5 0 "kein Phasengeber auf Nockenwelle verbaut" 1 "Phasengeber 1 auf Nockenwelle Einlass" 2 "Phasengeber 2 auf Nockenwelle Einlass" 3 "Phasengeber 3 auf Nockenwelle Einlass" 4 "Phasengeber 4 auf Nockenwelle Einlass" /end COMPU_VTAB
/begin COMPU_METHOD SY_NWMSV_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF SY_NWMSV_Compu /end COMPU_METHOD
/begin COMPU_VTAB SY_NWMSV_Compu "" TAB_VERB 7 0 "HDP mounted on fixed camshaft" 1 "HDP mounted on camshaft customer controlled" 2 "HDP mounted on inlet valve camshaft controlled" 3 "HDP mounted on outlet valve camshaft controlled" 4 "HDP mounted on inlet valve camshaft bank 2" 5 "HDP mounted on outlet valve camshaft bank 2" 6 "HDP mounted on intermediate shaft" /end COMPU_VTAB
/begin COMPU_METHOD SY_NWSA_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF SY_NWSA_Compu /end COMPU_METHOD
/begin COMPU_VTAB SY_NWSA_Compu "" TAB_VERB 3 0 "keine NWS Auslass" 1 "2-Punkt NWS Auslass" 2 "stetige NWS Auslass" /end COMPU_VTAB
/begin COMPU_METHOD SY_NWS_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF SY_NWS_Compu /end COMPU_METHOD
/begin COMPU_VTAB SY_NWS_Compu "" TAB_VERB 3 0 "keine Nockenwellensteuerung vorhanden" 1 "2 Punkt Nockenwellensteuerung vorhanden" 2 "kontinuierliche Nockenwellensteuerung vorhanden" /end COMPU_VTAB
/begin COMPU_METHOD SY_PID41_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF SY_PID41_Compu /end COMPU_METHOD
/begin COMPU_VTAB SY_PID41_Compu "" TAB_VERB 2 0 "Systemkonstante: PID$41" 1 "Systemkonstante: PID$41" /end COMPU_VTAB
/begin COMPU_METHOD SY_PSTDRST_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF SY_PSTDRST_Compu /end COMPU_METHOD
/begin COMPU_VTAB SY_PSTDRST_Compu "" TAB_VERB 2 0 "false" 1 "true" /end COMPU_VTAB
/begin COMPU_METHOD SY_RHMLS_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF SY_RHMLS_Compu /end COMPU_METHOD
/begin COMPU_VTAB SY_RHMLS_Compu "" TAB_VERB 4 0 "no heater resistor measurement" 1 "LSF3 downstream cat location of heater rest.meas." 2 "LSF2+3 downst. pre- and maincat loc. of the meas." 3 "LSF1+3 upst. frontcat and down. cat loc. of meas." /end COMPU_VTAB
/begin COMPU_METHOD SY_SALSU_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF SY_SALSU_Compu /end COMPU_METHOD
/begin COMPU_VTAB SY_SALSU_Compu "" TAB_VERB 2 0 "kein Schubabgleich" 1 "Schubabgleich vorhanden" /end COMPU_VTAB
/begin COMPU_METHOD SY_SCH_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF SY_SCH_Compu /end COMPU_METHOD
/begin COMPU_VTAB SY_SCH_Compu "" TAB_VERB 2 0 "False" 1 "True" /end COMPU_VTAB
/begin COMPU_METHOD SY_SGANZ_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF SY_SGANZ_Compu /end COMPU_METHOD
/begin COMPU_VTAB SY_SGANZ_Compu "" TAB_VERB 3 1 "Ein Steuergeräte Motormanagement Konzept" 2 "Zwei Steuergeräte Motormanagement Konzept" 3 "Drei Steuergeräte Motormanagement Konzept" /end COMPU_VTAB
/begin COMPU_METHOD SY_SLS_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF SY_SLS_Compu /end COMPU_METHOD
/begin COMPU_VTAB SY_SLS_Compu "" TAB_VERB 3 0 "keine Sekundärluftpumpe vorhanden" 1 "Sekundärluftpumpe vorhanden" 2 "GGSLSHFM vorhanden" /end COMPU_VTAB
/begin COMPU_METHOD SY_STASTO_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF SY_STASTO_Compu /end COMPU_METHOD
/begin COMPU_VTAB SY_STASTO_Compu "" TAB_VERB 2 0 "Kein Start-Stopp" 1 "Start-Stop vorhanden" /end COMPU_VTAB
/begin COMPU_METHOD SY_STA_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF SY_STA_Compu /end COMPU_METHOD
/begin COMPU_VTAB SY_STA_Compu "" TAB_VERB 2 0 "kein Automatikstart" 1 "Automatikstart" /end COMPU_VTAB
/begin COMPU_METHOD SY_STERHK_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF SY_STERHK_Compu /end COMPU_METHOD
/begin COMPU_VTAB SY_STERHK_Compu "" TAB_VERB 2 0 "Mono Lambdaregelung hinter KAT" 1 "Stereo Lambdaregelung hinter KAT" /end COMPU_VTAB
/begin COMPU_METHOD SY_STERSY_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF SY_STERSY_Compu /end COMPU_METHOD
/begin COMPU_VTAB SY_STERSY_Compu "" TAB_VERB 2 0 "Asymmetrische Abgasanlage" 1 "Symmetrische Abgasanlage" /end COMPU_VTAB
/begin COMPU_METHOD SY_STERVK_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF SY_STERVK_Compu /end COMPU_METHOD
/begin COMPU_VTAB SY_STERVK_Compu "" TAB_VERB 2 0 "Mono Lambdaregelung vor KAT" 1 "Stereo Lambdaregelung vor KAT" /end COMPU_VTAB
/begin COMPU_METHOD SY_SU4ST_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF SY_SU4ST_Compu /end COMPU_METHOD
/begin COMPU_VTAB SY_SU4ST_Compu "" TAB_VERB 2 0 "False" 1 "True" /end COMPU_VTAB
/begin COMPU_METHOD SY_SVBB_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF SY_SVBB_Compu /end COMPU_METHOD
/begin COMPU_VTAB SY_SVBB_Compu "" TAB_VERB 2 0 "NOSVBB" 1 "SVBBETAS" /end COMPU_VTAB
/begin COMPU_METHOD SY_TMMSV_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF SY_TMMSV_Compu /end COMPU_METHOD
/begin COMPU_VTAB SY_TMMSV_Compu "" TAB_VERB 2 0 "no_tmsvm" 1 "tmsvm_available" /end COMPU_VTAB
/begin COMPU_METHOD SY_TMSV_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF SY_TMSV_Compu /end COMPU_METHOD
/begin COMPU_VTAB SY_TMSV_Compu "" TAB_VERB 3 0 "no_TMSV" 1 "ATS_TMSV" 2 "FAATS_TMSV" /end COMPU_VTAB
/begin COMPU_METHOD SY_TPEACNR_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF SY_TPEACNR_Compu /end COMPU_METHOD
/begin COMPU_VTAB SY_TPEACNR_Compu "" TAB_VERB 2 0 "False" 1 "True" /end COMPU_VTAB
/begin COMPU_METHOD SY_TSPHK_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF SY_TSPHK_Compu /end COMPU_METHOD
/begin COMPU_VTAB SY_TSPHK_Compu "" TAB_VERB 2 0 "False" 1 "True" /end COMPU_VTAB
/begin COMPU_METHOD SY_TUMG_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF SY_TUMG_Compu /end COMPU_METHOD
/begin COMPU_VTAB SY_TUMG_Compu "" TAB_VERB 4 0 "no source, signal not available" 1 "Sensor" 2 "tans" 3 "CAN" /end COMPU_VTAB
/begin COMPU_METHOD SY_WMAX_Compu "" RAT_FUNC "%6.2" "" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD SY_WMIN_Compu "" RAT_FUNC "%6.2" "" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD SY_WNWADM_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF SY_WNWADM_Compu /end COMPU_METHOD
/begin COMPU_VTAB SY_WNWADM_Compu "" TAB_VERB 2 0 "Correction of camshaft angles by cam adaptation" 1 "No correction of cam angles by cam adapdaptation" /end COMPU_VTAB
/begin COMPU_METHOD SY_WPHN_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF SY_WPHN_Compu /end COMPU_METHOD
/begin COMPU_VTAB SY_WPHN_Compu "" TAB_VERB 2 0 "0" 1 "1" /end COMPU_VTAB
/begin COMPU_METHOD SY_ZGST_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF SY_ZGST_Compu /end COMPU_METHOD
/begin COMPU_VTAB SY_ZGST_Compu "" TAB_VERB 3 0 "SY_ZGST_0" 1 "SY_ZGST_1" 2 "SY_ZGST_2" /end COMPU_VTAB
/begin COMPU_METHOD SY_ZNDAUS_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF SY_ZNDAUS_Compu /end COMPU_METHOD
/begin COMPU_VTAB SY_ZNDAUS_Compu "" TAB_VERB 2 1 "Zündausgabe Einzelfunke" 2 "Zündausgabe Doppelfunke" /end COMPU_VTAB
/begin COMPU_METHOD SY_ZYLOFFH_Compu "" RAT_FUNC "%6.2" "" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD SY_ZYLOFFS_Compu "" RAT_FUNC "%6.2" "" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD SY_ZYLZA_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF SY_ZYLZA_Compu /end COMPU_METHOD
/begin COMPU_VTAB SY_ZYLZA_Compu "" TAB_VERB 10 2 "2" 3 "3" 4 "4" 5 "5" 6 "6" 8 "8" 10 "10" 12 "12" 16 "18" 18 "16" /end COMPU_VTAB
/begin COMPU_METHOD SY_ZYLZG_Compu "" RAT_FUNC "%6.2" "" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD SY_ZZBANK_Compu "" RAT_FUNC "%6.2" "" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD t100msxs_q16Em6 "" RAT_FUNC "%7.6" "s" COEFFS 0 1 0 0 0 1.6e-005 /end COMPU_METHOD
/begin COMPU_METHOD t100msxs_ub_b25p5 "" RAT_FUNC "%6.3" "s" COEFFS 0 1 0 0 0 0.1 /end COMPU_METHOD
/begin COMPU_METHOD T15_ATS_SY_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF T15_ATS_SY_Compu /end COMPU_METHOD
/begin COMPU_VTAB T15_ATS_SY_Compu "" TAB_VERB 2 0 "False" 1 "True" /end COMPU_VTAB
/begin COMPU_METHOD t1msxms_q1 "" RAT_FUNC "%6.2" "ms" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD t1p0usxms "" RAT_FUNC "%6.5" "ms" COEFFS 0 1000 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD TDC_ADAP_SY_Compu "" RAT_FUNC "%6.2" "" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD TDC_UNEQLGEOM_SY_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF TDC_UNEQLGEOM_SY_Compu /end COMPU_METHOD
/begin COMPU_VTAB TDC_UNEQLGEOM_SY_Compu "" TAB_VERB 2 0 "False" 1 "True" /end COMPU_VTAB
/begin COMPU_METHOD Temp2Dyc_COMPU "" RAT_FUNC "%6.4" "deg C/%" COEFFS 0 100 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD TempC_float "" RAT_FUNC "%6.1" "deg C" COEFFS 0 1 273.14 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD TempDiff_Kelv_1K "" RAT_FUNC "%6.2" "K" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD TempK_float "" RAT_FUNC "%6.2" "K" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD Temp_Cels "" RAT_FUNC "%6.1" "deg C" COEFFS 0 10 2731.4 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD Temp_Cels1 "" RAT_FUNC "%6.1" "deg C" COEFFS 0 100 27314 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD Temp_Cels_1deg "" RAT_FUNC "%6.1" "deg C" COEFFS 0 1 273.14 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD Time_ms "" RAT_FUNC "%6.1" "ms" COEFFS 0 0.1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD t_q0p01 "" RAT_FUNC "%6.4" "s" COEFFS 0 100 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD t_q0p05 "" RAT_FUNC "%6.4" "s" COEFFS 0 100 0 0 0 5 /end COMPU_METHOD
/begin COMPU_METHOD t_q0p1 "" RAT_FUNC "%6.3" "s" COEFFS 0 10 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD Vel "" RAT_FUNC "%6.4" "km/h" COEFFS 0 100 0 0 0 1 /end COMPU_METHOD
/end MODULE
/end PROJECT
