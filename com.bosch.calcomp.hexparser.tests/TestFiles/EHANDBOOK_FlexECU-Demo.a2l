ASAP2_VERSION 1 4
/begin PROJECT MED1734_Flx_G1 "MEDC17_Core"
/begin HEADER "" VERSION "MED1734_Flx_01" PROJECT_NO MED1734_Flx_G1 /end HEADER
/begin MODULE DIM ""
/begin MOD_COMMON "" BYTE_ORDER MSB_LAST ALIGNMENT_BYTE 1 ALIGNMENT_WORD 2 ALIGNMENT_LONG 4 ALIGNMENT_FLOAT32_IEEE 4 /end MOD_COMMON
/begin CHARACTERISTIC DSCHED_RmpSlpPas.FId_InhibitAlways_C "" VALUE 0x80283CB0 Val_Wu16 327675.0 DSCHED_RmpSlp 0.00 327675.0 FORMAT "%8.1" /end CHARACTERISTIC
/begin CHARACTERISTIC DSCHED_RmpSlpPas.FId_CoordTDCAdap_C "" VALUE 0x80283CB2 Val_Wu16 327675.0 DSCHED_RmpSlp 0.00 327675.0 FORMAT "%8.1" /end CHARACTERISTIC
/begin CHARACTERISTIC DSCHED_RmpUpLim.FId_InhibitAlways_C "" VALUE 0x80283CB4 Val_Wu16 65535.00 DFC_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DSCHED_RmpUpLim.FId_CoordTDCAdap_C "" VALUE 0x80283CB6 Val_Wu16 65535.00 DFC_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DSCHED_SetPointRateActv.FId_InhibitAlways_C "" VALUE 0x80283CB8 Val_Wu16 13107.00 DSCHED_Time200ms 0.00 13107.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DSCHED_SetPointRateActv.FId_CoordTDCAdap_C "" VALUE 0x80283CBA Val_Wu16 13107.00 DSCHED_Time200ms 0.00 13107.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DSCHED_SetPointRatePas.FId_InhibitAlways_C "" VALUE 0x80283CBC Val_Wu16 13107.00 DSCHED_Time200ms 0.00 13107.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DSCHED_SetPointRatePas.FId_CoordTDCAdap_C "" VALUE 0x80283CBE Val_Wu16 13107.00 DSCHED_Time200ms 0.00 13107.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DSCHED_stMode_C "" VALUE 0x80283CC0 Val_Wu8 255.0 DINH_OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC DSCHED_UpLimRateLow.FId_InhibitAlways_C "" VALUE 0x80283CC2 Val_Wu16 8191.000 DFC_OneToOne 0.00 8191.000 FORMAT "%8.3" /end CHARACTERISTIC
/begin CHARACTERISTIC DSCHED_UpLimRateLow.FId_CoordTDCAdap_C "" VALUE 0x80283CC4 Val_Wu16 8191.000 DFC_OneToOne 0.00 8191.000 FORMAT "%8.3" /end CHARACTERISTIC
/begin CHARACTERISTIC DSCHED_UpLimRateOk.FId_InhibitAlways_C "" VALUE 0x80283CC6 Val_Wu16 8191.000 DFC_OneToOne 0.00 8191.000 FORMAT "%8.3" /end CHARACTERISTIC
/begin CHARACTERISTIC DSCHED_UpLimRateOk.FId_CoordTDCAdap_C "" VALUE 0x80283CC8 Val_Wu16 8191.000 DFC_OneToOne 0.00 8191.000 FORMAT "%8.3" /end CHARACTERISTIC
/begin CHARACTERISTIC DSCHED_valDflOpMode_C "" VALUE 0x80283CCA Val_Wu16 65535.00 DINH_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DSCHED_valOfsPrioOpMode_C "" VALUE 0x80283CCC Val_Wu16 65535.00 DINH_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DSCHED_xSleepFId_CA "" VAL_BLK 0x80283CCE ValA_Wu8 2. DSCHED_FIdVerb 0.00 2. FORMAT "%2.0" NUMBER 5 /end CHARACTERISTIC
/begin CHARACTERISTIC DSMAUX_dtWUCMin_C "" VALUE 0x802836B2 Val_Ws16 6553.500 TempDiff_Kelv -3276.800 3276.700 FORMAT "%8.3" READ_ONLY /end CHARACTERISTIC
/begin CHARACTERISTIC DSMAUX_tWUCMin_C "" VALUE 0x802836B4 Val_Ws16 6553.500 Temp_Cels -3549.940 3003.560 FORMAT "%8.3" READ_ONLY /end CHARACTERISTIC
/begin CHARACTERISTIC DSMAUX_xClearMode_C "" VALUE 0x802836B6 Val_Wu16 424. DFC_Verb 0.00 424. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DSMAUX_xClearTrg_C "" VALUE 0x802836B8 Val_Wu8 255.0 DFC_OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC DSMDur_valEvntQntDist_C "" VALUE 0x802836BA Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DSMDur_valEvntQntTi_C "" VALUE 0x802836BC Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DSMDur_xEnaGlb_CA "" VAL_BLK 0x802836BE ValA_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" NUMBER 1 /end CHARACTERISTIC
/begin CHARACTERISTIC DSMDur_xRstGlb_CA "" VAL_BLK 0x802836C0 ValA_Wu8 255.0 DFES_OneToOne 0.00 255.0 FORMAT "%5.1" NUMBER 1 /end CHARACTERISTIC
/begin CHARACTERISTIC DSMDur_xSelEvntGlb_CA "" VAL_BLK 0x802836C1 ValA_Wu8 8.00000000000 DSMDur_EvntSel_Verb 0.00 8.00000000000 FORMAT "%13.11" NUMBER 1 /end CHARACTERISTIC
/begin CHARACTERISTIC DSMRdy_Grp.Cat_CA "" VAL_BLK 0x80283CDA ValA_Wu16 424. DFC_Verb 0.00 424. FORMAT "%2.0" READ_ONLY NUMBER 1 /end CHARACTERISTIC
/begin CHARACTERISTIC DSMRdy_Grp.HtCat_CA "" VAL_BLK 0x80283CDC ValA_Wu16 424. DFC_Verb 0.00 424. FORMAT "%2.0" READ_ONLY NUMBER 1 /end CHARACTERISTIC
/begin CHARACTERISTIC DSMRdy_Grp.EvpSys_CA "" VAL_BLK 0x80283CDE ValA_Wu16 424. DFC_Verb 0.00 424. FORMAT "%2.0" READ_ONLY NUMBER 1 /end CHARACTERISTIC
/begin CHARACTERISTIC DSMRdy_Grp.SecAirSys_CA "" VAL_BLK 0x80283CE0 ValA_Wu16 424. DFC_Verb 0.00 424. FORMAT "%2.0" READ_ONLY NUMBER 1 /end CHARACTERISTIC
/begin CHARACTERISTIC DSMRdy_Grp.O2Sens_CA "" VAL_BLK 0x80283CE4 ValA_Wu16 424. DFC_Verb 0.00 424. FORMAT "%2.0" READ_ONLY NUMBER 52 /end CHARACTERISTIC
/begin CHARACTERISTIC DSMRdy_Grp.O2SensHt_CA "" VAL_BLK 0x80283D4C ValA_Wu16 424. DFC_Verb 0.00 424. FORMAT "%2.0" READ_ONLY NUMBER 24 /end CHARACTERISTIC
/begin CHARACTERISTIC DSMRdy_Grp.EGR_CA "" VAL_BLK 0x80283D7C ValA_Wu16 424. DFC_Verb 0.00 424. FORMAT "%2.0" READ_ONLY NUMBER 1 /end CHARACTERISTIC
/begin CHARACTERISTIC DSMRdy_X.PID1ForceLowMsk_C "" VALUE 0x802836C4 Val_Wu32 4294967295.00 DSMRdy_OneToOne 0.00 4294967295.00 FORMAT "%13.2" READ_ONLY /end CHARACTERISTIC
/begin CHARACTERISTIC DSMRdy_X.PID1ForceHighMsk_C "" VALUE 0x802836C8 Val_Wu32 4294967295.00 DSMRdy_OneToOne 0.00 4294967295.00 FORMAT "%13.2" READ_ONLY /end CHARACTERISTIC
/begin CHARACTERISTIC DSMRdy_X.PID41ForceLowMsk_C "" VALUE 0x802836CC Val_Wu32 4294967295.00 DSMRdy_OneToOne 0.00 4294967295.00 FORMAT "%13.2" READ_ONLY /end CHARACTERISTIC
/begin CHARACTERISTIC DSMRdy_X.PID41ForceHighMsk_C "" VALUE 0x802836D0 Val_Wu32 4294967295.00 DSMRdy_OneToOne 0.00 4294967295.00 FORMAT "%13.2" READ_ONLY /end CHARACTERISTIC
/begin CHARACTERISTIC DTR_numCANOBDId_CA "" VAL_BLK 0x802836D4 ValA_Wu8 255.0 DFC_OneToOne 0.00 255.0 FORMAT "%5.1" NUMBER 6 /end CHARACTERISTIC
/begin CHARACTERISTIC DTR_numCANTstId_CA "" VAL_BLK 0x802836DA ValA_Wu8 255.0 DFC_OneToOne 0.00 255.0 FORMAT "%5.1" NUMBER 6 /end CHARACTERISTIC
/begin CHARACTERISTIC DTR_swtKLineOutVal_C "" VALUE 0x802836E0 Val_Wu8 1.000 OneToOne 0.00 1.000 FORMAT "%5.3" /end CHARACTERISTIC
/begin CHARACTERISTIC DTR_xAsgnCANRslt_CA "" VAL_BLK 0x802836E1 ValA_Wu8 255. DTR_Verb 0.00 255. FORMAT "%2.0" NUMBER 6 /end CHARACTERISTIC
/begin CHARACTERISTIC DTR_xAsgnKLineRslt_CA "" VAL_BLK 0x802836E7 ValA_Wu8 255. DTR_Verb 0.00 255. FORMAT "%2.0" NUMBER 1 /end CHARACTERISTIC
/begin CHARACTERISTIC DTR_xKLineCmpnId_CA "" VAL_BLK 0x802836E8 ValA_Wu8 255.0 DFC_OneToOne 0.00 255.0 FORMAT "%5.1" NUMBER 1 /end CHARACTERISTIC
/begin CHARACTERISTIC DTR_xKLineFactor_CA "" VAL_BLK 0x802836EA ValA_Ws16 7.999878 DTR_Fact -4.000000 3.999878 FORMAT "%8.6" NUMBER 1 /end CHARACTERISTIC
/begin CHARACTERISTIC DTR_xKLineOffset_CA "" VAL_BLK 0x802836EC ValA_Ws16 65535.00 DFC_OneToOne -32768.00 32767.00 FORMAT "%8.2" NUMBER 1 /end CHARACTERISTIC
/begin CHARACTERISTIC DTR_xKLineTstId_CA "" VAL_BLK 0x802836EE ValA_Wu8 255.0 DFC_OneToOne 0.00 255.0 FORMAT "%5.1" NUMBER 1 /end CHARACTERISTIC
/begin CHARACTERISTIC DUSHZK "" VALUE 0x80284430 KwWU16 319.9951 spg_q0p00488 0.00 319.9951 FORMAT "%8.4" /end CHARACTERISTIC
/begin CHARACTERISTIC DUSMINLP "" VALUE 0x80284440 KwWU16 319.9951 spg_q0p00488 0.00 319.9951 FORMAT "%8.4" /end CHARACTERISTIC
/begin CHARACTERISTIC DUSSIGLP "" VALUE 0x80284444 KwWU16 319.9951 spg_q0p00488 0.00 319.9951 FORMAT "%8.4" /end CHARACTERISTIC
/begin CHARACTERISTIC EEPRdErr_Datalost_CW "" VALUE 0x802B9740 Val_Wu8 255.0 default 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC EEPRdErr_Redundant_CW "" VALUE 0x802B9741 Val_Wu8 255.0 default 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Eep_ClrWrCounter_CW "" VALUE 0x802B9742 Val_Wu8 255.0 default 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Eep_EnFirstFactoryMark_CW "" VALUE 0x802B9743 Val_Wu8 255.0 default 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Eep_EnFirstInit_CW "" VALUE 0x802B9744 Val_Wu8 255.0 default 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Eep_EnvRamClr_CW "" VALUE 0x802B9745 Val_Wu8 255.0 default 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC ENHLSF.CWHZLSF "" VALUE 0x80284834 KwWU8 255.0 dez 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC ENHLSH.CWHZLSF "" VALUE 0x8028483C KwWU8 255.0 dez 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC ENHLSV.CWHZLSF "" VALUE 0x80284844 KwWU8 255.0 dez 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC EpmBCa_facSegTimeAcc_C "" VALUE 0x802B9746 Val_Ws16 5.000000 EpmBCa_FacTstInj 0.00 5.000000 FORMAT "%8.6" /end CHARACTERISTIC
/begin CHARACTERISTIC EpmBCa_facSegTimeConstHigh_C "" VALUE 0x802B9748 Val_Ws16 5.000000 EpmBCa_FacTstInj 0.00 5.000000 FORMAT "%8.6" /end CHARACTERISTIC
/begin CHARACTERISTIC EpmBCa_facSegTimeConstLow_C "" VALUE 0x802B974A Val_Ws16 5.000000 EpmBCa_FacTstInj 0.00 5.000000 FORMAT "%8.6" /end CHARACTERISTIC
/begin CHARACTERISTIC EpmBCa_nTstInjMax_C "" VALUE 0x802B974C Val_Ws16 8000.000 EngN 0.00 8000.000 FORMAT "%8.3" /end CHARACTERISTIC
/begin CHARACTERISTIC EpmBCa_numInjSer_C "" VALUE 0x802B974E Val_Wu8 9.000 OneToOne 1.000 10.00 FORMAT "%5.2" /end CHARACTERISTIC
/begin CHARACTERISTIC EpmBCa_numTstInjMax_C "" VALUE 0x802B9750 Val_Wu16 16000.00 OneToOne 0.00 16000.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC EpmBCa_phiSegEndOld_C "" VALUE 0x802B9752 Val_Ws16 719.9780 AngleCrS 0.00 719.9780 FORMAT "%8.4" /end CHARACTERISTIC
/begin CHARACTERISTIC EpmBCa_phiSegLen_C "" VALUE 0x802B9754 Val_Ws16 189.9976 AngleCrS 9.997559 199.9951 FORMAT "%8.4" /end CHARACTERISTIC
/begin CHARACTERISTIC EpmCaS_dSegSeries_CA "" VAL_BLK 0x802B9778 ValA_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" NUMBER 48 /end CHARACTERISTIC
/begin CHARACTERISTIC EpmCaS_numSegSerLst_C "" VALUE 0x802B97BC Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC EpmCaS_phiLoLimIn_C "" VALUE 0x802B97BE Val_Ws16 1439.978 AngleCrS -720.0000 719.9780 FORMAT "%8.4" /end CHARACTERISTIC
/begin CHARACTERISTIC EpmCaS_phiLoLimOut_C "" VALUE 0x802B97C0 Val_Ws16 1439.978 AngleCrS -720.0000 719.9780 FORMAT "%8.4" /end CHARACTERISTIC
/begin CHARACTERISTIC EpmCaS_phiSegLenTol_CA "" VAL_BLK 0x802B97DC ValA_Ws16 1439.978 AngleCrS -720.0000 719.9780 FORMAT "%8.4" NUMBER 16 /end CHARACTERISTIC
/begin CHARACTERISTIC EpmCaS_phiSegLen_CA "" VAL_BLK 0x802B97FC ValA_Ws16 719.9780 AngleCrS 0.00 719.9780 FORMAT "%8.4" NUMBER 16 /end CHARACTERISTIC
/begin CHARACTERISTIC EpmCaS_phiSegOfs_CA "" VAL_BLK 0x802B981C ValA_Ws16 719.9780 AngleCrS 0.00 719.9780 FORMAT "%8.4" NUMBER 4 /end CHARACTERISTIC
/begin AXIS_PTS EpmCaS_phiTempCor05_DST "" 0x802B9824 EngDa_tEng Axis_Xs16 65535. OneToOne 3 -32768. 32767. FORMAT "%5.0" DEPOSIT ABSOLUTE /end AXIS_PTS
/begin CHARACTERISTIC EpmCaS_phiTempCorI2_GCUR "" CURVE 0x802B9832 CurG_Ws16 1439.978 AngleCrS -720.0000 719.9780 FORMAT "%8.4"
 /begin AXIS_DESCR COM_AXIS EngDa_tEng OneToOne 3 -32768. 32767. FORMAT "%5.0" AXIS_PTS_REF EpmCaS_phiTempCor05_DST /end AXIS_DESCR
/end CHARACTERISTIC
/begin CHARACTERISTIC EpmCaS_phiTempCorO2_GCUR "" CURVE 0x802B983E CurG_Ws16 1439.978 AngleCrS -720.0000 719.9780 FORMAT "%8.4"
 /begin AXIS_DESCR COM_AXIS EngDa_tEng OneToOne 3 -32768. 32767. FORMAT "%5.0" AXIS_PTS_REF EpmCaS_phiTempCor05_DST /end AXIS_DESCR
/end CHARACTERISTIC
/begin CHARACTERISTIC EpmCaS_stActEdge_C "" VALUE 0x802B9848 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC EpmCaS_stMinSyncCaSAg_C "" VALUE 0x802B9849 Val_Wu8 20.00 OneToOne 10.00 30.00 FORMAT "%5.2" /end CHARACTERISTIC
/begin CHARACTERISTIC EpmCaS_swtAdapStgy_C "" VALUE 0x802B9760 Val_Wu8 1.000 OneToOne 0.00 1.000 FORMAT "%5.3" /end CHARACTERISTIC
/begin CHARACTERISTIC EpmCaS_swtCamShTyp_C "" VALUE 0x802B9761 Val_Wu8 1.000 OneToOne 0.00 1.000 FORMAT "%5.3" /end CHARACTERISTIC
/begin CHARACTERISTIC EpmCaS_swtI1Ena_C "" VALUE 0x802B98EC Val_Wu8 1.000 OneToOne 0.00 1.000 FORMAT "%5.3" /end CHARACTERISTIC
/begin CHARACTERISTIC EpmCaS_swtI2Ena_C "" VALUE 0x802B98ED Val_Wu8 1.000 OneToOne 0.00 1.000 FORMAT "%5.3" /end CHARACTERISTIC
/begin CHARACTERISTIC EpmCaS_swtO1Ena_C "" VALUE 0x802B98EE Val_Wu8 1.000 OneToOne 0.00 1.000 FORMAT "%5.3" /end CHARACTERISTIC
/begin CHARACTERISTIC EpmCaS_swtO2Ena_C "" VALUE 0x802B98EF Val_Wu8 1.000 OneToOne 0.00 1.000 FORMAT "%5.3" /end CHARACTERISTIC
/begin CHARACTERISTIC EpmCaS_swtSeg_C "" VALUE 0x802B984A Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC EpmCaS_tiGlitchFilter_C "" VALUE 0x802B984C Val_Ws32 4294967295.00 OneToOne_us -2147483648.00 2147483647.00 FORMAT "%13.2" /end CHARACTERISTIC
/begin CHARACTERISTIC EpmCaS_tiTimeout_C "" VALUE 0x802B9850 Val_Ws32 42949672950.0 Time_ms -21474836480.0 21474836470.0 FORMAT "%13.1" /end CHARACTERISTIC
/begin CHARACTERISTIC EpmCrS_facGapCrit1_C "" VALUE 0x802B9874 Val_Wu8 15.94 EPM_FAC_PLAUS 0.00 15.94 FORMAT "%5.2" /end CHARACTERISTIC
/begin CHARACTERISTIC EpmCrS_facGapCrit2_C "" VALUE 0x802B9875 Val_Wu8 15.94 EPM_FAC_PLAUS 0.00 15.94 FORMAT "%5.2" /end CHARACTERISTIC
/begin CHARACTERISTIC EpmCrS_facGapPlausHigh_CA "" VAL_BLK 0x802B9876 ValA_Wu8 15.94 EPM_FAC_PLAUS 0.00 15.94 FORMAT "%5.2" NUMBER 4 /end CHARACTERISTIC
/begin CHARACTERISTIC EpmCrS_facIncPlausHigh_CA "" VAL_BLK 0x802B987A ValA_Wu8 15.94 EPM_FAC_PLAUS 0.00 15.94 FORMAT "%5.2" NUMBER 4 /end CHARACTERISTIC
/begin CHARACTERISTIC EpmCrS_facIncPlausLow_CA "" VAL_BLK 0x802B987E ValA_Wu8 15.94 EPM_FAC_PLAUS 0.00 15.94 FORMAT "%5.2" NUMBER 4 /end CHARACTERISTIC
/begin CHARACTERISTIC EpmCrS_numGap_C "" VALUE 0x802B98F0 Val_Wu8 2.000 OneToOne 0.00 2.000 FORMAT "%5.3" /end CHARACTERISTIC
/begin CHARACTERISTIC EpmCrS_numIncGap_C "" VALUE 0x802B98F1 Val_Wu8 1.000 OneToOne 2.000 3.000 FORMAT "%5.3" /end CHARACTERISTIC
/begin CHARACTERISTIC EpmCrS_numInc_C "" VALUE 0x802B98F2 Val_Wu8 24.00 OneToOne 36.00 60.00 FORMAT "%5.2" /end CHARACTERISTIC
/begin CHARACTERISTIC EpmCrS_tiGlitchFilter_CA "" VAL_BLK 0x802B98AC ValA_Ws32 100000.000000 OneToOne_us 0.00 100000.000000 FORMAT "%13.6" NUMBER 4 /end CHARACTERISTIC
/begin CHARACTERISTIC EpmCrS_tiIgnSig_C "" VALUE 0x802B98BC Val_Ws32 100000.000000 OneToOne_ms 0.00 100000.000000 FORMAT "%13.6" /end CHARACTERISTIC
/begin CHARACTERISTIC EpmSeq_phiInt_CA "" VAL_BLK 0x802B98C8 ValA_Ws16 719.9780 AngleCrS 0.00 719.9780 FORMAT "%8.4" NUMBER 2 /end CHARACTERISTIC
/begin CHARACTERISTIC EpmSeq_phiStrtInt_CA "" VAL_BLK 0x802B98CC ValA_Ws16 719.9780 AngleCrS 0.00 719.9780 FORMAT "%8.4" NUMBER 2 /end CHARACTERISTIC
/begin CHARACTERISTIC EpmSeq_phiSyncInt_C "" VALUE 0x802B98D0 Val_Ws16 719.9780 AngleCrS 0.00 719.9780 FORMAT "%8.4" /end CHARACTERISTIC
/begin CHARACTERISTIC EpmSeq_swtInt_C "" VALUE 0x802B98D2 Val_Wu8 15.00 OneToOne 0.00 15.00 FORMAT "%5.2" /end CHARACTERISTIC
/begin CHARACTERISTIC EpmSyn_dCaSSegMsk_C "" VALUE 0x802B98D4 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC EpmSyn_dTrigMsk_C "" VALUE 0x802B98D5 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC EpmSyn_dTrigRslt_C "" VALUE 0x802B98D6 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC EpmSyn_phiIncCor_CUR "" CURVE 0x802B98DA Cur_Xs16Ws16 39.99023 AngleCrS -19.99512 19.99512 FORMAT "%8.5"
 /begin AXIS_DESCR STD_AXIS Epm_nEng EngN 4 -16384.00 16383.50 FORMAT "%8.2" DEPOSIT ABSOLUTE /end AXIS_DESCR
/end CHARACTERISTIC
/begin CHARACTERISTIC EpmSyn_phiTrig_C "" VALUE 0x802B98D8 Val_Ws16 1439.978 AngleCrS -720.0000 719.9780 FORMAT "%8.4" /end CHARACTERISTIC
/begin CHARACTERISTIC Epm_numCyl_C "" VALUE 0x802B98F3 Val_Wu8 7.000 OneToOne 1.000 8.000 FORMAT "%5.3" /end CHARACTERISTIC
/begin CHARACTERISTIC Epm_numFireSeg_C "" VAL_BLK 0x802B98F4 ValA_Wu8 7.000 OneToOne 1.000 8.000 FORMAT "%5.3" NUMBER 8 /end CHARACTERISTIC
/begin CHARACTERISTIC Epm_phiGap2Zero_C "" VALUE 0x802B98FC Val_Ws16 359.9780 AngleCrS 0.00 359.9780 FORMAT "%8.4" /end CHARACTERISTIC
/begin CHARACTERISTIC Epm_phiTdc1_C "" VALUE 0x802B98FE Val_Ws16 719.9780 AngleCrS 0.00 719.9780 FORMAT "%8.4" /end CHARACTERISTIC
/begin CHARACTERISTIC Epm_swtBlkInjCaSSync_C "" VALUE 0x802B9905 Val_Wu8 1.000 OneToOne 0.00 1.000 FORMAT "%5.3" /end CHARACTERISTIC
/begin CHARACTERISTIC ESC_stS1FrstSched_C "" VALUE 0x802B973C Val_Wu8 3.00000000000 ESC_stS1FrstSched_t 0.00 3.00000000000 FORMAT "%13.11" /end CHARACTERISTIC
/begin CHARACTERISTIC Etc_MaxReqTO_C "" VALUE 0x802B973E Val_Wu16 32767.00 OneToOne 0.00 32767.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC FARIN "" VALUE 0x80284756 KwWU16 1023.984 rpspg_q0p0156 0.00 1023.984 FORMAT "%8.3" /end CHARACTERISTIC
/begin CHARACTERISTIC FIPLSU "" VALUE 0x80284574 KwWU16 16383.75 ispg_q0p25 0.00 16383.75 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC FLSUFTKL "" VALUE 0x802845CC KwWU16 3.999939 fak_uw_b4 0.00 3.999939 FORMAT "%8.6" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG1_HDL0SchedCount_C "Scheduling Count of the message buffer for Group 1 Handle 0" VALUE 0x80282774 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG1_HDL0SchedMode_C "Scheduling Mode of the message buffer for Group 1 Handle 0" VALUE 0x80282773 Val_Wu8 4.00000000000 TaskCycleFieldSelRx 0.00 4.00000000000 FORMAT "%13.11" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG1_HDL0TOCount_C "message Counter for Group 1 Handle 0" VALUE 0x80282772 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG1_HDL10SchedCount_C "Scheduling Count of the message buffer for Group 1 Handle 10" VALUE 0x80282771 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG1_HDL10SchedMode_C "Scheduling Mode of the message buffer for Group 1 Handle 10" VALUE 0x80282770 Val_Wu8 4.00000000000 TaskCycleFieldSelRx 0.00 4.00000000000 FORMAT "%13.11" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG1_HDL10TOCount_C "message Counter for Group 1 Handle 10" VALUE 0x8028276F Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG1_HDL11SchedCount_C "Scheduling Count of the message buffer for Group 1 Handle 11" VALUE 0x8028276E Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG1_HDL11SchedMode_C "Scheduling Mode of the message buffer for Group 1 Handle 11" VALUE 0x8028276D Val_Wu8 4.00000000000 TaskCycleFieldSelRx 0.00 4.00000000000 FORMAT "%13.11" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG1_HDL11TOCount_C "message Counter for Group 1 Handle 11" VALUE 0x8028276C Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG1_HDL12SchedCount_C "Scheduling Count of the message buffer for Group 1 Handle 12" VALUE 0x8028276B Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG1_HDL12SchedMode_C "Scheduling Mode of the message buffer for Group 1 Handle 12" VALUE 0x8028276A Val_Wu8 4.00000000000 TaskCycleFieldSelRx 0.00 4.00000000000 FORMAT "%13.11" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG1_HDL12TOCount_C "message Counter for Group 1 Handle 12" VALUE 0x80282769 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG1_HDL13SchedCount_C "Scheduling Count of the message buffer for Group 1 Handle 13" VALUE 0x80282768 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG1_HDL13SchedMode_C "Scheduling Mode of the message buffer for Group 1 Handle 13" VALUE 0x80282767 Val_Wu8 4.00000000000 TaskCycleFieldSelRx 0.00 4.00000000000 FORMAT "%13.11" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG1_HDL13TOCount_C "message Counter for Group 1 Handle 13" VALUE 0x80282766 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG1_HDL14SchedCount_C "Scheduling Count of the message buffer for Group 1 Handle 14" VALUE 0x80282765 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG1_HDL14SchedMode_C "Scheduling Mode of the message buffer for Group 1 Handle 14" VALUE 0x80282764 Val_Wu8 4.00000000000 TaskCycleFieldSelRx 0.00 4.00000000000 FORMAT "%13.11" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG1_HDL14TOCount_C "message Counter for Group 1 Handle 14" VALUE 0x80282763 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG1_HDL15SchedCount_C "Scheduling Count of the message buffer for Group 1 Handle 15" VALUE 0x80282762 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG1_HDL15SchedMode_C "Scheduling Mode of the message buffer for Group 1 Handle 15" VALUE 0x80282761 Val_Wu8 4.00000000000 TaskCycleFieldSelRx 0.00 4.00000000000 FORMAT "%13.11" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG1_HDL15TOCount_C "message Counter for Group 1 Handle 15" VALUE 0x80282760 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG1_HDL16SchedCount_C "Scheduling Count of the message buffer for Group 1 Handle 16" VALUE 0x8028275F Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG1_HDL16SchedMode_C "Scheduling Mode of the message buffer for Group 1 Handle 16" VALUE 0x8028275E Val_Wu8 4.00000000000 TaskCycleFieldSelRx 0.00 4.00000000000 FORMAT "%13.11" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG1_HDL16TOCount_C "message Counter for Group 1 Handle 16" VALUE 0x8028275D Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG1_HDL17SchedCount_C "Scheduling Count of the message buffer for Group 1 Handle 17" VALUE 0x8028275C Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG1_HDL17SchedMode_C "Scheduling Mode of the message buffer for Group 1 Handle 17" VALUE 0x8028275B Val_Wu8 4.00000000000 TaskCycleFieldSelRx 0.00 4.00000000000 FORMAT "%13.11" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG1_HDL17TOCount_C "message Counter for Group 1 Handle 17" VALUE 0x8028275A Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG1_HDL18SchedCount_C "Scheduling Count of the message buffer for Group 1 Handle 18" VALUE 0x80282759 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG1_HDL18SchedMode_C "Scheduling Mode of the message buffer for Group 1 Handle 18" VALUE 0x80282758 Val_Wu8 4.00000000000 TaskCycleFieldSelRx 0.00 4.00000000000 FORMAT "%13.11" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG1_HDL18TOCount_C "message Counter for Group 1 Handle 18" VALUE 0x80282757 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG1_HDL19SchedCount_C "Scheduling Count of the message buffer for Group 1 Handle 19" VALUE 0x80282756 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG1_HDL19SchedMode_C "Scheduling Mode of the message buffer for Group 1 Handle 19" VALUE 0x80282755 Val_Wu8 4.00000000000 TaskCycleFieldSelRx 0.00 4.00000000000 FORMAT "%13.11" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG1_HDL19TOCount_C "message Counter for Group 1 Handle 19" VALUE 0x80282754 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG1_HDL1SchedCount_C "Scheduling Count of the message buffer for Group 1 Handle 1" VALUE 0x80282753 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG1_HDL1SchedMode_C "Scheduling Mode of the message buffer for Group 1 Handle 1" VALUE 0x80282752 Val_Wu8 4.00000000000 TaskCycleFieldSelRx 0.00 4.00000000000 FORMAT "%13.11" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG1_HDL1TOCount_C "message Counter for Group 1 Handle 1" VALUE 0x80282751 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG1_HDL20SchedCount_C "Scheduling Count of the message buffer for Group 1 Handle 20" VALUE 0x80282750 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG1_HDL20SchedMode_C "Scheduling Mode of the message buffer for Group 1 Handle 20" VALUE 0x8028274F Val_Wu8 4.00000000000 TaskCycleFieldSelRx 0.00 4.00000000000 FORMAT "%13.11" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG1_HDL20TOCount_C "message Counter for Group 1 Handle 20" VALUE 0x8028274E Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG1_HDL21SchedCount_C "Scheduling Count of the message buffer for Group 1 Handle 21" VALUE 0x8028274D Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG1_HDL21SchedMode_C "Scheduling Mode of the message buffer for Group 1 Handle 21" VALUE 0x8028274C Val_Wu8 4.00000000000 TaskCycleFieldSelRx 0.00 4.00000000000 FORMAT "%13.11" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG1_HDL21TOCount_C "message Counter for Group 1 Handle 21" VALUE 0x8028274B Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG1_HDL22SchedCount_C "Scheduling Count of the message buffer for Group 1 Handle 22" VALUE 0x8028274A Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG1_HDL22SchedMode_C "Scheduling Mode of the message buffer for Group 1 Handle 22" VALUE 0x80282749 Val_Wu8 4.00000000000 TaskCycleFieldSelRx 0.00 4.00000000000 FORMAT "%13.11" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG1_HDL22TOCount_C "message Counter for Group 1 Handle 22" VALUE 0x80282748 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG1_HDL23SchedCount_C "Scheduling Count of the message buffer for Group 1 Handle 23" VALUE 0x80282747 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG1_HDL23SchedMode_C "Scheduling Mode of the message buffer for Group 1 Handle 23" VALUE 0x80282746 Val_Wu8 4.00000000000 TaskCycleFieldSelRx 0.00 4.00000000000 FORMAT "%13.11" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG1_HDL23TOCount_C "message Counter for Group 1 Handle 23" VALUE 0x80282745 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG1_HDL24SchedCount_C "Scheduling Count of the message buffer for Group 1 Handle 24" VALUE 0x80282744 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG1_HDL24SchedMode_C "Scheduling Mode of the message buffer for Group 1 Handle 24" VALUE 0x80282743 Val_Wu8 4.00000000000 TaskCycleFieldSelRx 0.00 4.00000000000 FORMAT "%13.11" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG1_HDL24TOCount_C "message Counter for Group 1 Handle 24" VALUE 0x80282742 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG1_HDL2SchedCount_C "Scheduling Count of the message buffer for Group 1 Handle 2" VALUE 0x80282741 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG1_HDL2SchedMode_C "Scheduling Mode of the message buffer for Group 1 Handle 2" VALUE 0x80282740 Val_Wu8 4.00000000000 TaskCycleFieldSelRx 0.00 4.00000000000 FORMAT "%13.11" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG1_HDL2TOCount_C "message Counter for Group 1 Handle 2" VALUE 0x8028273F Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG1_HDL3SchedCount_C "Scheduling Count of the message buffer for Group 1 Handle 3" VALUE 0x8028273E Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG1_HDL3SchedMode_C "Scheduling Mode of the message buffer for Group 1 Handle 3" VALUE 0x8028273D Val_Wu8 4.00000000000 TaskCycleFieldSelRx 0.00 4.00000000000 FORMAT "%13.11" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG1_HDL3TOCount_C "message Counter for Group 1 Handle 3" VALUE 0x8028273C Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG1_HDL4SchedCount_C "Scheduling Count of the message buffer for Group 1 Handle 4" VALUE 0x8028273B Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG1_HDL4SchedMode_C "Scheduling Mode of the message buffer for Group 1 Handle 4" VALUE 0x8028273A Val_Wu8 4.00000000000 TaskCycleFieldSelRx 0.00 4.00000000000 FORMAT "%13.11" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG1_HDL4TOCount_C "message Counter for Group 1 Handle 4" VALUE 0x80282739 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG1_HDL5SchedCount_C "Scheduling Count of the message buffer for Group 1 Handle 5" VALUE 0x80282738 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG1_HDL5SchedMode_C "Scheduling Mode of the message buffer for Group 1 Handle 5" VALUE 0x80282737 Val_Wu8 4.00000000000 TaskCycleFieldSelRx 0.00 4.00000000000 FORMAT "%13.11" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG1_HDL5TOCount_C "message Counter for Group 1 Handle 5" VALUE 0x80282736 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG1_HDL6SchedCount_C "Scheduling Count of the message buffer for Group 1 Handle 6" VALUE 0x80282735 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG1_HDL6SchedMode_C "Scheduling Mode of the message buffer for Group 1 Handle 6" VALUE 0x80282734 Val_Wu8 4.00000000000 TaskCycleFieldSelRx 0.00 4.00000000000 FORMAT "%13.11" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG1_HDL6TOCount_C "message Counter for Group 1 Handle 6" VALUE 0x80282733 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG1_HDL7SchedCount_C "Scheduling Count of the message buffer for Group 1 Handle 7" VALUE 0x80282732 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG1_HDL7SchedMode_C "Scheduling Mode of the message buffer for Group 1 Handle 7" VALUE 0x80282731 Val_Wu8 4.00000000000 TaskCycleFieldSelRx 0.00 4.00000000000 FORMAT "%13.11" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG1_HDL7TOCount_C "message Counter for Group 1 Handle 7" VALUE 0x80282730 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG1_HDL8SchedCount_C "Scheduling Count of the message buffer for Group 1 Handle 8" VALUE 0x8028272F Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG1_HDL8SchedMode_C "Scheduling Mode of the message buffer for Group 1 Handle 8" VALUE 0x8028272E Val_Wu8 4.00000000000 TaskCycleFieldSelRx 0.00 4.00000000000 FORMAT "%13.11" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG1_HDL8TOCount_C "message Counter for Group 1 Handle 8" VALUE 0x8028272D Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG1_HDL9SchedCount_C "Scheduling Count of the message buffer for Group 1 Handle 9" VALUE 0x8028272C Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG1_HDL9SchedMode_C "Scheduling Mode of the message buffer for Group 1 Handle 9" VALUE 0x8028272B Val_Wu8 4.00000000000 TaskCycleFieldSelRx 0.00 4.00000000000 FORMAT "%13.11" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG1_HDL9TOCount_C "message Counter for Group 1 Handle 9" VALUE 0x8028272A Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG2_HDL0SchedCount_C "Scheduling Count of the message buffer for Group 2 Handle 0" VALUE 0x80282729 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG2_HDL0SchedMode_C "Scheduling Mode of the message buffer for Group 2 Handle 0" VALUE 0x80282728 Val_Wu8 4.00000000000 TaskCycleFieldSelRx 0.00 4.00000000000 FORMAT "%13.11" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG2_HDL0TOCount_C "message Counter for Group 2 Handle 0" VALUE 0x80282727 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG2_HDL10SchedCount_C "Scheduling Count of the message buffer for Group 2 Handle 10" VALUE 0x80282726 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG2_HDL10SchedMode_C "Scheduling Mode of the message buffer for Group 2 Handle 10" VALUE 0x80282725 Val_Wu8 4.00000000000 TaskCycleFieldSelRx 0.00 4.00000000000 FORMAT "%13.11" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG2_HDL10TOCount_C "message Counter for Group 2 Handle 10" VALUE 0x80282724 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG2_HDL11SchedCount_C "Scheduling Count of the message buffer for Group 2 Handle 11" VALUE 0x80282723 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG2_HDL11SchedMode_C "Scheduling Mode of the message buffer for Group 2 Handle 11" VALUE 0x80282722 Val_Wu8 4.00000000000 TaskCycleFieldSelRx 0.00 4.00000000000 FORMAT "%13.11" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG2_HDL11TOCount_C "message Counter for Group 2 Handle 11" VALUE 0x80282721 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG2_HDL12SchedCount_C "Scheduling Count of the message buffer for Group 2 Handle 12" VALUE 0x80282720 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG2_HDL12SchedMode_C "Scheduling Mode of the message buffer for Group 2 Handle 12" VALUE 0x8028271F Val_Wu8 4.00000000000 TaskCycleFieldSelRx 0.00 4.00000000000 FORMAT "%13.11" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG2_HDL12TOCount_C "message Counter for Group 2 Handle 12" VALUE 0x8028271E Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG2_HDL13SchedCount_C "Scheduling Count of the message buffer for Group 2 Handle 13" VALUE 0x8028271D Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG2_HDL13SchedMode_C "Scheduling Mode of the message buffer for Group 2 Handle 13" VALUE 0x8028271C Val_Wu8 4.00000000000 TaskCycleFieldSelRx 0.00 4.00000000000 FORMAT "%13.11" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG2_HDL13TOCount_C "message Counter for Group 2 Handle 13" VALUE 0x8028271B Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG2_HDL14SchedCount_C "Scheduling Count of the message buffer for Group 2 Handle 14" VALUE 0x8028271A Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG2_HDL14SchedMode_C "Scheduling Mode of the message buffer for Group 2 Handle 14" VALUE 0x80282719 Val_Wu8 4.00000000000 TaskCycleFieldSelRx 0.00 4.00000000000 FORMAT "%13.11" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG2_HDL14TOCount_C "message Counter for Group 2 Handle 14" VALUE 0x80282718 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG2_HDL15SchedCount_C "Scheduling Count of the message buffer for Group 2 Handle 15" VALUE 0x80282717 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG2_HDL15SchedMode_C "Scheduling Mode of the message buffer for Group 2 Handle 15" VALUE 0x80282716 Val_Wu8 4.00000000000 TaskCycleFieldSelRx 0.00 4.00000000000 FORMAT "%13.11" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG2_HDL15TOCount_C "message Counter for Group 2 Handle 15" VALUE 0x80282715 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG2_HDL16SchedCount_C "Scheduling Count of the message buffer for Group 2 Handle 16" VALUE 0x80282714 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG2_HDL16SchedMode_C "Scheduling Mode of the message buffer for Group 2 Handle 16" VALUE 0x80282713 Val_Wu8 4.00000000000 TaskCycleFieldSelRx 0.00 4.00000000000 FORMAT "%13.11" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG2_HDL16TOCount_C "message Counter for Group 2 Handle 16" VALUE 0x80282712 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG2_HDL17SchedCount_C "Scheduling Count of the message buffer for Group 2 Handle 17" VALUE 0x80282711 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG2_HDL17SchedMode_C "Scheduling Mode of the message buffer for Group 2 Handle 17" VALUE 0x80282710 Val_Wu8 4.00000000000 TaskCycleFieldSelRx 0.00 4.00000000000 FORMAT "%13.11" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG2_HDL17TOCount_C "message Counter for Group 2 Handle 17" VALUE 0x8028270F Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG2_HDL18SchedCount_C "Scheduling Count of the message buffer for Group 2 Handle 18" VALUE 0x8028270E Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG2_HDL18SchedMode_C "Scheduling Mode of the message buffer for Group 2 Handle 18" VALUE 0x8028270D Val_Wu8 4.00000000000 TaskCycleFieldSelRx 0.00 4.00000000000 FORMAT "%13.11" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG2_HDL18TOCount_C "message Counter for Group 2 Handle 18" VALUE 0x8028270C Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG2_HDL19SchedCount_C "Scheduling Count of the message buffer for Group 2 Handle 19" VALUE 0x8028270B Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG2_HDL19SchedMode_C "Scheduling Mode of the message buffer for Group 2 Handle 19" VALUE 0x8028270A Val_Wu8 4.00000000000 TaskCycleFieldSelRx 0.00 4.00000000000 FORMAT "%13.11" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG2_HDL19TOCount_C "message Counter for Group 2 Handle 19" VALUE 0x80282709 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG2_HDL1SchedCount_C "Scheduling Count of the message buffer for Group 2 Handle 1" VALUE 0x80282708 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG2_HDL1SchedMode_C "Scheduling Mode of the message buffer for Group 2 Handle 1" VALUE 0x80282707 Val_Wu8 4.00000000000 TaskCycleFieldSelRx 0.00 4.00000000000 FORMAT "%13.11" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG2_HDL1TOCount_C "message Counter for Group 2 Handle 1" VALUE 0x80282706 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG2_HDL20SchedCount_C "Scheduling Count of the message buffer for Group 2 Handle 20" VALUE 0x80282705 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG2_HDL20SchedMode_C "Scheduling Mode of the message buffer for Group 2 Handle 20" VALUE 0x80282704 Val_Wu8 4.00000000000 TaskCycleFieldSelRx 0.00 4.00000000000 FORMAT "%13.11" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG2_HDL20TOCount_C "message Counter for Group 2 Handle 20" VALUE 0x80282703 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG2_HDL21SchedCount_C "Scheduling Count of the message buffer for Group 2 Handle 21" VALUE 0x80282702 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG2_HDL21SchedMode_C "Scheduling Mode of the message buffer for Group 2 Handle 21" VALUE 0x80282701 Val_Wu8 4.00000000000 TaskCycleFieldSelRx 0.00 4.00000000000 FORMAT "%13.11" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG2_HDL21TOCount_C "message Counter for Group 2 Handle 21" VALUE 0x80282700 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG2_HDL22SchedCount_C "Scheduling Count of the message buffer for Group 2 Handle 22" VALUE 0x802826FF Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG2_HDL22SchedMode_C "Scheduling Mode of the message buffer for Group 2 Handle 22" VALUE 0x802826FE Val_Wu8 4.00000000000 TaskCycleFieldSelRx 0.00 4.00000000000 FORMAT "%13.11" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG2_HDL22TOCount_C "message Counter for Group 2 Handle 22" VALUE 0x802826FD Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG2_HDL23SchedCount_C "Scheduling Count of the message buffer for Group 2 Handle 23" VALUE 0x802826FC Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG2_HDL23SchedMode_C "Scheduling Mode of the message buffer for Group 2 Handle 23" VALUE 0x802826FB Val_Wu8 4.00000000000 TaskCycleFieldSelRx 0.00 4.00000000000 FORMAT "%13.11" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG2_HDL23TOCount_C "message Counter for Group 2 Handle 23" VALUE 0x802826FA Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG2_HDL24SchedCount_C "Scheduling Count of the message buffer for Group 2 Handle 24" VALUE 0x802826F9 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG2_HDL24SchedMode_C "Scheduling Mode of the message buffer for Group 2 Handle 24" VALUE 0x802826F8 Val_Wu8 4.00000000000 TaskCycleFieldSelRx 0.00 4.00000000000 FORMAT "%13.11" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG2_HDL24TOCount_C "message Counter for Group 2 Handle 24" VALUE 0x802826F7 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG2_HDL2SchedCount_C "Scheduling Count of the message buffer for Group 2 Handle 2" VALUE 0x802826F6 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG2_HDL2SchedMode_C "Scheduling Mode of the message buffer for Group 2 Handle 2" VALUE 0x802826F5 Val_Wu8 4.00000000000 TaskCycleFieldSelRx 0.00 4.00000000000 FORMAT "%13.11" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG2_HDL2TOCount_C "message Counter for Group 2 Handle 2" VALUE 0x802826F4 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG2_HDL3SchedCount_C "Scheduling Count of the message buffer for Group 2 Handle 3" VALUE 0x802826F3 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG2_HDL3SchedMode_C "Scheduling Mode of the message buffer for Group 2 Handle 3" VALUE 0x802826F2 Val_Wu8 4.00000000000 TaskCycleFieldSelRx 0.00 4.00000000000 FORMAT "%13.11" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG2_HDL3TOCount_C "message Counter for Group 2 Handle 3" VALUE 0x802826F1 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG2_HDL4SchedCount_C "Scheduling Count of the message buffer for Group 2 Handle 4" VALUE 0x802826F0 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG2_HDL4SchedMode_C "Scheduling Mode of the message buffer for Group 2 Handle 4" VALUE 0x802826EF Val_Wu8 4.00000000000 TaskCycleFieldSelRx 0.00 4.00000000000 FORMAT "%13.11" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG2_HDL4TOCount_C "message Counter for Group 2 Handle 4" VALUE 0x802826EE Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG2_HDL5SchedCount_C "Scheduling Count of the message buffer for Group 2 Handle 5" VALUE 0x802826ED Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG2_HDL5SchedMode_C "Scheduling Mode of the message buffer for Group 2 Handle 5" VALUE 0x802826EC Val_Wu8 4.00000000000 TaskCycleFieldSelRx 0.00 4.00000000000 FORMAT "%13.11" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG2_HDL5TOCount_C "message Counter for Group 2 Handle 5" VALUE 0x802826EB Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG2_HDL6SchedCount_C "Scheduling Count of the message buffer for Group 2 Handle 6" VALUE 0x802826EA Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG2_HDL6SchedMode_C "Scheduling Mode of the message buffer for Group 2 Handle 6" VALUE 0x802826E9 Val_Wu8 4.00000000000 TaskCycleFieldSelRx 0.00 4.00000000000 FORMAT "%13.11" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG2_HDL6TOCount_C "message Counter for Group 2 Handle 6" VALUE 0x802826E8 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG2_HDL7SchedCount_C "Scheduling Count of the message buffer for Group 2 Handle 7" VALUE 0x802826E7 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG2_HDL7SchedMode_C "Scheduling Mode of the message buffer for Group 2 Handle 7" VALUE 0x802826E6 Val_Wu8 4.00000000000 TaskCycleFieldSelRx 0.00 4.00000000000 FORMAT "%13.11" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG2_HDL7TOCount_C "message Counter for Group 2 Handle 7" VALUE 0x802826E5 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG2_HDL8SchedCount_C "Scheduling Count of the message buffer for Group 2 Handle 8" VALUE 0x802826E4 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG2_HDL8SchedMode_C "Scheduling Mode of the message buffer for Group 2 Handle 8" VALUE 0x802826E3 Val_Wu8 4.00000000000 TaskCycleFieldSelRx 0.00 4.00000000000 FORMAT "%13.11" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG2_HDL8TOCount_C "message Counter for Group 2 Handle 8" VALUE 0x802826E2 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG2_HDL9SchedCount_C "Scheduling Count of the message buffer for Group 2 Handle 9" VALUE 0x802826E1 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG2_HDL9SchedMode_C "Scheduling Mode of the message buffer for Group 2 Handle 9" VALUE 0x802826E0 Val_Wu8 4.00000000000 TaskCycleFieldSelRx 0.00 4.00000000000 FORMAT "%13.11" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG2_HDL9TOCount_C "message Counter for Group 2 Handle 9" VALUE 0x802826DF Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG3_HDL0SchedCount_C "Scheduling Count of the message buffer for Group 3 Handle 0" VALUE 0x802826DE Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG3_HDL0SchedMode_C "Scheduling Mode of the message buffer for Group 3 Handle 0" VALUE 0x802826DD Val_Wu8 4.00000000000 TaskCycleFieldSelRx 0.00 4.00000000000 FORMAT "%13.11" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG3_HDL0TOCount_C "message Counter for Group 3 Handle 0" VALUE 0x802826DC Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG3_HDL10SchedCount_C "Scheduling Count of the message buffer for Group 3 Handle 10" VALUE 0x802826DB Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG3_HDL10SchedMode_C "Scheduling Mode of the message buffer for Group 3 Handle 10" VALUE 0x802826DA Val_Wu8 4.00000000000 TaskCycleFieldSelRx 0.00 4.00000000000 FORMAT "%13.11" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG3_HDL10TOCount_C "message Counter for Group 3 Handle 10" VALUE 0x802826D9 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG3_HDL11SchedCount_C "Scheduling Count of the message buffer for Group 3 Handle 11" VALUE 0x802826D8 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG3_HDL11SchedMode_C "Scheduling Mode of the message buffer for Group 3 Handle 11" VALUE 0x802826D7 Val_Wu8 4.00000000000 TaskCycleFieldSelRx 0.00 4.00000000000 FORMAT "%13.11" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG3_HDL11TOCount_C "message Counter for Group 3 Handle 11" VALUE 0x802826D6 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG3_HDL12SchedCount_C "Scheduling Count of the message buffer for Group 3 Handle 12" VALUE 0x802826D5 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG3_HDL12SchedMode_C "Scheduling Mode of the message buffer for Group 3 Handle 12" VALUE 0x802826D4 Val_Wu8 4.00000000000 TaskCycleFieldSelRx 0.00 4.00000000000 FORMAT "%13.11" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG3_HDL12TOCount_C "message Counter for Group 3 Handle 12" VALUE 0x802826D3 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG3_HDL13SchedCount_C "Scheduling Count of the message buffer for Group 3 Handle 13" VALUE 0x802826D2 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG3_HDL13SchedMode_C "Scheduling Mode of the message buffer for Group 3 Handle 13" VALUE 0x802826D1 Val_Wu8 4.00000000000 TaskCycleFieldSelRx 0.00 4.00000000000 FORMAT "%13.11" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG3_HDL13TOCount_C "message Counter for Group 3 Handle 13" VALUE 0x802826D0 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG3_HDL14SchedCount_C "Scheduling Count of the message buffer for Group 3 Handle 14" VALUE 0x802826CF Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG3_HDL14SchedMode_C "Scheduling Mode of the message buffer for Group 3 Handle 14" VALUE 0x802826CE Val_Wu8 4.00000000000 TaskCycleFieldSelRx 0.00 4.00000000000 FORMAT "%13.11" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG3_HDL14TOCount_C "message Counter for Group 3 Handle 14" VALUE 0x802826CD Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG3_HDL15SchedCount_C "Scheduling Count of the message buffer for Group 3 Handle 15" VALUE 0x802826CC Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG3_HDL15SchedMode_C "Scheduling Mode of the message buffer for Group 3 Handle 15" VALUE 0x802826CB Val_Wu8 4.00000000000 TaskCycleFieldSelRx 0.00 4.00000000000 FORMAT "%13.11" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG3_HDL15TOCount_C "message Counter for Group 3 Handle 15" VALUE 0x802826CA Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG3_HDL16SchedCount_C "Scheduling Count of the message buffer for Group 3 Handle 16" VALUE 0x802826C9 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG3_HDL16SchedMode_C "Scheduling Mode of the message buffer for Group 3 Handle 16" VALUE 0x802826C8 Val_Wu8 4.00000000000 TaskCycleFieldSelRx 0.00 4.00000000000 FORMAT "%13.11" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG3_HDL16TOCount_C "message Counter for Group 3 Handle 16" VALUE 0x802826C7 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG3_HDL17SchedCount_C "Scheduling Count of the message buffer for Group 3 Handle 17" VALUE 0x802826C6 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG3_HDL17SchedMode_C "Scheduling Mode of the message buffer for Group 3 Handle 17" VALUE 0x802826C5 Val_Wu8 4.00000000000 TaskCycleFieldSelRx 0.00 4.00000000000 FORMAT "%13.11" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG3_HDL17TOCount_C "message Counter for Group 3 Handle 17" VALUE 0x802826C4 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG3_HDL18SchedCount_C "Scheduling Count of the message buffer for Group 3 Handle 18" VALUE 0x802826C3 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG3_HDL18SchedMode_C "Scheduling Mode of the message buffer for Group 3 Handle 18" VALUE 0x802826C2 Val_Wu8 4.00000000000 TaskCycleFieldSelRx 0.00 4.00000000000 FORMAT "%13.11" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG3_HDL18TOCount_C "message Counter for Group 3 Handle 18" VALUE 0x802826C1 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG3_HDL19SchedCount_C "Scheduling Count of the message buffer for Group 3 Handle 19" VALUE 0x802826C0 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG3_HDL19SchedMode_C "Scheduling Mode of the message buffer for Group 3 Handle 19" VALUE 0x802826BF Val_Wu8 4.00000000000 TaskCycleFieldSelRx 0.00 4.00000000000 FORMAT "%13.11" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG3_HDL19TOCount_C "message Counter for Group 3 Handle 19" VALUE 0x802826BE Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG3_HDL1SchedCount_C "Scheduling Count of the message buffer for Group 3 Handle 1" VALUE 0x802826BD Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG3_HDL1SchedMode_C "Scheduling Mode of the message buffer for Group 3 Handle 1" VALUE 0x802826BC Val_Wu8 4.00000000000 TaskCycleFieldSelRx 0.00 4.00000000000 FORMAT "%13.11" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG3_HDL1TOCount_C "message Counter for Group 3 Handle 1" VALUE 0x802826BB Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG3_HDL20SchedCount_C "Scheduling Count of the message buffer for Group 3 Handle 20" VALUE 0x802826BA Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG3_HDL20SchedMode_C "Scheduling Mode of the message buffer for Group 3 Handle 20" VALUE 0x802826B9 Val_Wu8 4.00000000000 TaskCycleFieldSelRx 0.00 4.00000000000 FORMAT "%13.11" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG3_HDL20TOCount_C "message Counter for Group 3 Handle 20" VALUE 0x802826B8 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG3_HDL21SchedCount_C "Scheduling Count of the message buffer for Group 3 Handle 21" VALUE 0x802826B7 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG3_HDL21SchedMode_C "Scheduling Mode of the message buffer for Group 3 Handle 21" VALUE 0x802826B6 Val_Wu8 4.00000000000 TaskCycleFieldSelRx 0.00 4.00000000000 FORMAT "%13.11" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG3_HDL21TOCount_C "message Counter for Group 3 Handle 21" VALUE 0x802826B5 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG3_HDL22SchedCount_C "Scheduling Count of the message buffer for Group 3 Handle 22" VALUE 0x802826B4 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG3_HDL22SchedMode_C "Scheduling Mode of the message buffer for Group 3 Handle 22" VALUE 0x802826B3 Val_Wu8 4.00000000000 TaskCycleFieldSelRx 0.00 4.00000000000 FORMAT "%13.11" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG3_HDL22TOCount_C "message Counter for Group 3 Handle 22" VALUE 0x802826B2 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG3_HDL23SchedCount_C "Scheduling Count of the message buffer for Group 3 Handle 23" VALUE 0x802826B1 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG3_HDL23SchedMode_C "Scheduling Mode of the message buffer for Group 3 Handle 23" VALUE 0x802826B0 Val_Wu8 4.00000000000 TaskCycleFieldSelRx 0.00 4.00000000000 FORMAT "%13.11" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG3_HDL23TOCount_C "message Counter for Group 3 Handle 23" VALUE 0x802826AF Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG3_HDL24SchedCount_C "Scheduling Count of the message buffer for Group 3 Handle 24" VALUE 0x802826AE Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG3_HDL24SchedMode_C "Scheduling Mode of the message buffer for Group 3 Handle 24" VALUE 0x802826AD Val_Wu8 4.00000000000 TaskCycleFieldSelRx 0.00 4.00000000000 FORMAT "%13.11" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG3_HDL24TOCount_C "message Counter for Group 3 Handle 24" VALUE 0x802826AC Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG3_HDL2SchedCount_C "Scheduling Count of the message buffer for Group 3 Handle 2" VALUE 0x802826AB Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG3_HDL2SchedMode_C "Scheduling Mode of the message buffer for Group 3 Handle 2" VALUE 0x802826AA Val_Wu8 4.00000000000 TaskCycleFieldSelRx 0.00 4.00000000000 FORMAT "%13.11" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG3_HDL2TOCount_C "message Counter for Group 3 Handle 2" VALUE 0x802826A9 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG3_HDL3SchedCount_C "Scheduling Count of the message buffer for Group 3 Handle 3" VALUE 0x802826A8 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG3_HDL3SchedMode_C "Scheduling Mode of the message buffer for Group 3 Handle 3" VALUE 0x802826A7 Val_Wu8 4.00000000000 TaskCycleFieldSelRx 0.00 4.00000000000 FORMAT "%13.11" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG3_HDL3TOCount_C "message Counter for Group 3 Handle 3" VALUE 0x802826A6 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG3_HDL4SchedCount_C "Scheduling Count of the message buffer for Group 3 Handle 4" VALUE 0x802826A5 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG3_HDL4SchedMode_C "Scheduling Mode of the message buffer for Group 3 Handle 4" VALUE 0x802826A4 Val_Wu8 4.00000000000 TaskCycleFieldSelRx 0.00 4.00000000000 FORMAT "%13.11" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG3_HDL4TOCount_C "message Counter for Group 3 Handle 4" VALUE 0x802826A3 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG3_HDL5SchedCount_C "Scheduling Count of the message buffer for Group 3 Handle 5" VALUE 0x802826A2 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG3_HDL5SchedMode_C "Scheduling Mode of the message buffer for Group 3 Handle 5" VALUE 0x802826A1 Val_Wu8 4.00000000000 TaskCycleFieldSelRx 0.00 4.00000000000 FORMAT "%13.11" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG3_HDL5TOCount_C "message Counter for Group 3 Handle 5" VALUE 0x802826A0 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG3_HDL6SchedCount_C "Scheduling Count of the message buffer for Group 3 Handle 6" VALUE 0x8028269F Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG3_HDL6SchedMode_C "Scheduling Mode of the message buffer for Group 3 Handle 6" VALUE 0x8028269E Val_Wu8 4.00000000000 TaskCycleFieldSelRx 0.00 4.00000000000 FORMAT "%13.11" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG3_HDL6TOCount_C "message Counter for Group 3 Handle 6" VALUE 0x8028269D Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG3_HDL7SchedCount_C "Scheduling Count of the message buffer for Group 3 Handle 7" VALUE 0x8028269C Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG3_HDL7SchedMode_C "Scheduling Mode of the message buffer for Group 3 Handle 7" VALUE 0x8028269B Val_Wu8 4.00000000000 TaskCycleFieldSelRx 0.00 4.00000000000 FORMAT "%13.11" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG3_HDL7TOCount_C "message Counter for Group 3 Handle 7" VALUE 0x8028269A Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG3_HDL8SchedCount_C "Scheduling Count of the message buffer for Group 3 Handle 8" VALUE 0x80282699 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG3_HDL8SchedMode_C "Scheduling Mode of the message buffer for Group 3 Handle 8" VALUE 0x80282698 Val_Wu8 4.00000000000 TaskCycleFieldSelRx 0.00 4.00000000000 FORMAT "%13.11" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG3_HDL8TOCount_C "message Counter for Group 3 Handle 8" VALUE 0x80282697 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG3_HDL9SchedCount_C "Scheduling Count of the message buffer for Group 3 Handle 9" VALUE 0x80282696 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG3_HDL9SchedMode_C "Scheduling Mode of the message buffer for Group 3 Handle 9" VALUE 0x80282695 Val_Wu8 4.00000000000 TaskCycleFieldSelRx 0.00 4.00000000000 FORMAT "%13.11" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG3_HDL9TOCount_C "message Counter for Group 3 Handle 9" VALUE 0x80282694 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG4_HDL0SchedCount_C "Scheduling Count of the message buffer for Group 4 Handle 0" VALUE 0x80282693 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG4_HDL0SchedMode_C "Scheduling Mode of the message buffer for Group 4 Handle 0" VALUE 0x80282692 Val_Wu8 4.00000000000 TaskCycleFieldSelTx 0.00 4.00000000000 FORMAT "%13.11" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG4_HDL0TOCount_C "message Counter for Group 4 Handle 0" VALUE 0x80282691 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG4_HDL10SchedCount_C "Scheduling Count of the message buffer for Group 4 Handle 10" VALUE 0x80282690 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG4_HDL10SchedMode_C "Scheduling Mode of the message buffer for Group 4 Handle 10" VALUE 0x8028268F Val_Wu8 4.00000000000 TaskCycleFieldSelTx 0.00 4.00000000000 FORMAT "%13.11" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG4_HDL10TOCount_C "message Counter for Group 4 Handle 10" VALUE 0x8028268E Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG4_HDL11SchedCount_C "Scheduling Count of the message buffer for Group 4 Handle 11" VALUE 0x8028268D Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG4_HDL11SchedMode_C "Scheduling Mode of the message buffer for Group 4 Handle 11" VALUE 0x8028268C Val_Wu8 4.00000000000 TaskCycleFieldSelTx 0.00 4.00000000000 FORMAT "%13.11" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG4_HDL11TOCount_C "message Counter for Group 4 Handle 11" VALUE 0x8028268B Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG4_HDL12SchedCount_C "Scheduling Count of the message buffer for Group 4 Handle 12" VALUE 0x8028268A Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG4_HDL12SchedMode_C "Scheduling Mode of the message buffer for Group 4 Handle 12" VALUE 0x80282689 Val_Wu8 4.00000000000 TaskCycleFieldSelTx 0.00 4.00000000000 FORMAT "%13.11" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG4_HDL12TOCount_C "message Counter for Group 4 Handle 12" VALUE 0x80282688 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG4_HDL13SchedCount_C "Scheduling Count of the message buffer for Group 4 Handle 13" VALUE 0x80282687 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG4_HDL13SchedMode_C "Scheduling Mode of the message buffer for Group 4 Handle 13" VALUE 0x80282686 Val_Wu8 4.00000000000 TaskCycleFieldSelTx 0.00 4.00000000000 FORMAT "%13.11" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG4_HDL13TOCount_C "message Counter for Group 4 Handle 13" VALUE 0x80282685 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG4_HDL14SchedCount_C "Scheduling Count of the message buffer for Group 4 Handle 14" VALUE 0x80282684 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG4_HDL14SchedMode_C "Scheduling Mode of the message buffer for Group 4 Handle 14" VALUE 0x80282683 Val_Wu8 4.00000000000 TaskCycleFieldSelTx 0.00 4.00000000000 FORMAT "%13.11" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG4_HDL14TOCount_C "message Counter for Group 4 Handle 14" VALUE 0x80282682 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG4_HDL15SchedCount_C "Scheduling Count of the message buffer for Group 4 Handle 15" VALUE 0x80282681 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG4_HDL15SchedMode_C "Scheduling Mode of the message buffer for Group 4 Handle 15" VALUE 0x80282680 Val_Wu8 4.00000000000 TaskCycleFieldSelTx 0.00 4.00000000000 FORMAT "%13.11" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG4_HDL15TOCount_C "message Counter for Group 4 Handle 15" VALUE 0x8028267F Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG4_HDL16SchedCount_C "Scheduling Count of the message buffer for Group 4 Handle 16" VALUE 0x8028267E Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG4_HDL16SchedMode_C "Scheduling Mode of the message buffer for Group 4 Handle 16" VALUE 0x8028267D Val_Wu8 4.00000000000 TaskCycleFieldSelTx 0.00 4.00000000000 FORMAT "%13.11" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG4_HDL16TOCount_C "message Counter for Group 4 Handle 16" VALUE 0x8028267C Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG4_HDL17SchedCount_C "Scheduling Count of the message buffer for Group 4 Handle 17" VALUE 0x8028267B Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG4_HDL17SchedMode_C "Scheduling Mode of the message buffer for Group 4 Handle 17" VALUE 0x8028267A Val_Wu8 4.00000000000 TaskCycleFieldSelTx 0.00 4.00000000000 FORMAT "%13.11" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG4_HDL17TOCount_C "message Counter for Group 4 Handle 17" VALUE 0x80282679 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG4_HDL18SchedCount_C "Scheduling Count of the message buffer for Group 4 Handle 18" VALUE 0x80282678 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG4_HDL18SchedMode_C "Scheduling Mode of the message buffer for Group 4 Handle 18" VALUE 0x80282677 Val_Wu8 4.00000000000 TaskCycleFieldSelTx 0.00 4.00000000000 FORMAT "%13.11" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG4_HDL18TOCount_C "message Counter for Group 4 Handle 18" VALUE 0x80282676 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG4_HDL19SchedCount_C "Scheduling Count of the message buffer for Group 4 Handle 19" VALUE 0x80282675 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG4_HDL19SchedMode_C "Scheduling Mode of the message buffer for Group 4 Handle 19" VALUE 0x80282674 Val_Wu8 4.00000000000 TaskCycleFieldSelTx 0.00 4.00000000000 FORMAT "%13.11" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG4_HDL19TOCount_C "message Counter for Group 4 Handle 19" VALUE 0x80282673 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG4_HDL1SchedCount_C "Scheduling Count of the message buffer for Group 4 Handle 1" VALUE 0x80282672 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG4_HDL1SchedMode_C "Scheduling Mode of the message buffer for Group 4 Handle 1" VALUE 0x80282671 Val_Wu8 4.00000000000 TaskCycleFieldSelTx 0.00 4.00000000000 FORMAT "%13.11" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG4_HDL1TOCount_C "message Counter for Group 4 Handle 1" VALUE 0x80282670 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG4_HDL20SchedCount_C "Scheduling Count of the message buffer for Group 4 Handle 20" VALUE 0x8028266F Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG4_HDL20SchedMode_C "Scheduling Mode of the message buffer for Group 4 Handle 20" VALUE 0x8028266E Val_Wu8 4.00000000000 TaskCycleFieldSelTx 0.00 4.00000000000 FORMAT "%13.11" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG4_HDL20TOCount_C "message Counter for Group 4 Handle 20" VALUE 0x8028266D Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG4_HDL21SchedCount_C "Scheduling Count of the message buffer for Group 4 Handle 21" VALUE 0x8028266C Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG4_HDL21SchedMode_C "Scheduling Mode of the message buffer for Group 4 Handle 21" VALUE 0x8028266B Val_Wu8 4.00000000000 TaskCycleFieldSelTx 0.00 4.00000000000 FORMAT "%13.11" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG4_HDL21TOCount_C "message Counter for Group 4 Handle 21" VALUE 0x8028266A Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG4_HDL22SchedCount_C "Scheduling Count of the message buffer for Group 4 Handle 22" VALUE 0x80282669 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG4_HDL22SchedMode_C "Scheduling Mode of the message buffer for Group 4 Handle 22" VALUE 0x80282668 Val_Wu8 4.00000000000 TaskCycleFieldSelTx 0.00 4.00000000000 FORMAT "%13.11" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG4_HDL22TOCount_C "message Counter for Group 4 Handle 22" VALUE 0x80282667 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG4_HDL23SchedCount_C "Scheduling Count of the message buffer for Group 4 Handle 23" VALUE 0x80282666 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG4_HDL23SchedMode_C "Scheduling Mode of the message buffer for Group 4 Handle 23" VALUE 0x80282665 Val_Wu8 4.00000000000 TaskCycleFieldSelTx 0.00 4.00000000000 FORMAT "%13.11" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG4_HDL23TOCount_C "message Counter for Group 4 Handle 23" VALUE 0x80282664 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG4_HDL24SchedCount_C "Scheduling Count of the message buffer for Group 4 Handle 24" VALUE 0x80282663 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG4_HDL24SchedMode_C "Scheduling Mode of the message buffer for Group 4 Handle 24" VALUE 0x80282662 Val_Wu8 4.00000000000 TaskCycleFieldSelTx 0.00 4.00000000000 FORMAT "%13.11" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG4_HDL24TOCount_C "message Counter for Group 4 Handle 24" VALUE 0x80282661 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG4_HDL2SchedCount_C "Scheduling Count of the message buffer for Group 4 Handle 2" VALUE 0x80282660 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG4_HDL2SchedMode_C "Scheduling Mode of the message buffer for Group 4 Handle 2" VALUE 0x8028265F Val_Wu8 4.00000000000 TaskCycleFieldSelTx 0.00 4.00000000000 FORMAT "%13.11" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG4_HDL2TOCount_C "message Counter for Group 4 Handle 2" VALUE 0x8028265E Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG4_HDL3SchedCount_C "Scheduling Count of the message buffer for Group 4 Handle 3" VALUE 0x8028265D Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG4_HDL3SchedMode_C "Scheduling Mode of the message buffer for Group 4 Handle 3" VALUE 0x8028265C Val_Wu8 4.00000000000 TaskCycleFieldSelTx 0.00 4.00000000000 FORMAT "%13.11" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG4_HDL3TOCount_C "message Counter for Group 4 Handle 3" VALUE 0x8028265B Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG4_HDL4SchedCount_C "Scheduling Count of the message buffer for Group 4 Handle 4" VALUE 0x8028265A Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG4_HDL4SchedMode_C "Scheduling Mode of the message buffer for Group 4 Handle 4" VALUE 0x80282659 Val_Wu8 4.00000000000 TaskCycleFieldSelTx 0.00 4.00000000000 FORMAT "%13.11" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG4_HDL4TOCount_C "message Counter for Group 4 Handle 4" VALUE 0x80282658 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG4_HDL5SchedCount_C "Scheduling Count of the message buffer for Group 4 Handle 5" VALUE 0x80282657 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG4_HDL5SchedMode_C "Scheduling Mode of the message buffer for Group 4 Handle 5" VALUE 0x80282656 Val_Wu8 4.00000000000 TaskCycleFieldSelTx 0.00 4.00000000000 FORMAT "%13.11" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG4_HDL5TOCount_C "message Counter for Group 4 Handle 5" VALUE 0x80282655 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG4_HDL6SchedCount_C "Scheduling Count of the message buffer for Group 4 Handle 6" VALUE 0x80282654 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG4_HDL6SchedMode_C "Scheduling Mode of the message buffer for Group 4 Handle 6" VALUE 0x80282653 Val_Wu8 4.00000000000 TaskCycleFieldSelTx 0.00 4.00000000000 FORMAT "%13.11" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG4_HDL6TOCount_C "message Counter for Group 4 Handle 6" VALUE 0x80282652 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG4_HDL7SchedCount_C "Scheduling Count of the message buffer for Group 4 Handle 7" VALUE 0x80282651 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG4_HDL7SchedMode_C "Scheduling Mode of the message buffer for Group 4 Handle 7" VALUE 0x80282650 Val_Wu8 4.00000000000 TaskCycleFieldSelTx 0.00 4.00000000000 FORMAT "%13.11" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG4_HDL7TOCount_C "message Counter for Group 4 Handle 7" VALUE 0x8028264F Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG4_HDL8SchedCount_C "Scheduling Count of the message buffer for Group 4 Handle 8" VALUE 0x8028264E Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG4_HDL8SchedMode_C "Scheduling Mode of the message buffer for Group 4 Handle 8" VALUE 0x8028264D Val_Wu8 4.00000000000 TaskCycleFieldSelTx 0.00 4.00000000000 FORMAT "%13.11" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG4_HDL8TOCount_C "message Counter for Group 4 Handle 8" VALUE 0x8028264C Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG4_HDL9SchedCount_C "Scheduling Count of the message buffer for Group 4 Handle 9" VALUE 0x8028264B Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG4_HDL9SchedMode_C "Scheduling Mode of the message buffer for Group 4 Handle 9" VALUE 0x8028264A Val_Wu8 4.00000000000 TaskCycleFieldSelTx 0.00 4.00000000000 FORMAT "%13.11" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_CANG4_HDL9TOCount_C "message Counter for Group 4 Handle 9" VALUE 0x80282649 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_MoFFrmFalsify_C "" VALUE 0x80282778 Val_Wu8 3.000 OneToOne 0.00 3.000 FORMAT "%5.3" /end CHARACTERISTIC
/begin CHARACTERISTIC Frm_trqRefRet_C "" VALUE 0x802B951C Val_Ws16 3277.800 Trq -3276.800 1.000000 FORMAT "%8.3" /end CHARACTERISTIC
/begin CHARACTERISTIC FRSNAMX "" VALUE 0x802843CE KwWU16 1.999969 fak_uw_b2 0.00 1.999969 FORMAT "%8.6" /end CHARACTERISTIC
/begin CHARACTERISTIC GGLSF2ZA.TUSRIBER "" VALUE 0x80284710 KwWU8 2.550 t_q0p01 0.00 2.550 FORMAT "%5.3" /end CHARACTERISTIC
/begin CHARACTERISTIC GGLSF2ZA.USRIO "" VALUE 0x80284712 KwWU16 319.9951 spg_uw_q0p00488 0.00 319.9951 FORMAT "%8.4" /end CHARACTERISTIC
/begin CHARACTERISTIC GGLSF2ZA.USRIU "" VALUE 0x80284714 KwWU16 319.9951 spg_uw_q0p00488 0.00 319.9951 FORMAT "%8.4" /end CHARACTERISTIC
/begin CHARACTERISTIC GGLSFZA.TUSRIBER "" VALUE 0x8028471C KwWU8 2.550 t_q0p01 0.00 2.550 FORMAT "%5.3" /end CHARACTERISTIC
/begin CHARACTERISTIC GGLSFZA.USRIO "" VALUE 0x8028471E KwWU16 319.9951 spg_uw_q0p00488 0.00 319.9951 FORMAT "%8.4" /end CHARACTERISTIC
/begin CHARACTERISTIC GGLSFZA.USRIU "" VALUE 0x80284720 KwWU16 319.9951 spg_uw_q0p00488 0.00 319.9951 FORMAT "%8.4" /end CHARACTERISTIC
/begin CHARACTERISTIC GGLSH2ZA.TUSRIBER "" VALUE 0x80284728 KwWU8 2.550 t_q0p01 0.00 2.550 FORMAT "%5.3" /end CHARACTERISTIC
/begin CHARACTERISTIC GGLSH2ZA.USRIO "" VALUE 0x8028472A KwWU16 319.9951 spg_uw_q0p00488 0.00 319.9951 FORMAT "%8.4" /end CHARACTERISTIC
/begin CHARACTERISTIC GGLSH2ZA.USRIU "" VALUE 0x8028472C KwWU16 319.9951 spg_uw_q0p00488 0.00 319.9951 FORMAT "%8.4" /end CHARACTERISTIC
/begin CHARACTERISTIC GGLSHZA.TUSRIBER "" VALUE 0x80284734 KwWU8 2.550 t_q0p01 0.00 2.550 FORMAT "%5.3" /end CHARACTERISTIC
/begin CHARACTERISTIC GGLSHZA.USRIO "" VALUE 0x80284736 KwWU16 319.9951 spg_uw_q0p00488 0.00 319.9951 FORMAT "%8.4" /end CHARACTERISTIC
/begin CHARACTERISTIC GGLSHZA.USRIU "" VALUE 0x80284738 KwWU16 319.9951 spg_uw_q0p00488 0.00 319.9951 FORMAT "%8.4" /end CHARACTERISTIC
/begin CHARACTERISTIC GGLSV2ZA.TUSRIBER "" VALUE 0x80284740 KwWU8 2.550 t_q0p01 0.00 2.550 FORMAT "%5.3" /end CHARACTERISTIC
/begin CHARACTERISTIC GGLSV2ZA.USRIO "" VALUE 0x80284742 KwWU16 319.9951 spg_uw_q0p00488 0.00 319.9951 FORMAT "%8.4" /end CHARACTERISTIC
/begin CHARACTERISTIC GGLSV2ZA.USRIU "" VALUE 0x80284744 KwWU16 319.9951 spg_uw_q0p00488 0.00 319.9951 FORMAT "%8.4" /end CHARACTERISTIC
/begin CHARACTERISTIC GGLSVZA.TUSRIBER "" VALUE 0x8028474C KwWU8 2.550 t_q0p01 0.00 2.550 FORMAT "%5.3" /end CHARACTERISTIC
/begin CHARACTERISTIC GGLSVZA.USRIO "" VALUE 0x8028474E KwWU16 319.9951 spg_uw_q0p00488 0.00 319.9951 FORMAT "%8.4" /end CHARACTERISTIC
/begin CHARACTERISTIC GGLSVZA.USRIU "" VALUE 0x80284750 KwWU16 319.9951 spg_uw_q0p00488 0.00 319.9951 FORMAT "%8.4" /end CHARACTERISTIC
/begin CHARACTERISTIC HLSF.CWHLS "" VALUE 0x8028484C KwWU8 255.0 dez 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC HLSF.KFHSUSOL "" MAP 0x8028484E KfAxU8AyU8SstxU16SstyU16WU16 25.59961 spg_q0p00039 0.00 25.59961 FORMAT "%8.5"
 /begin AXIS_DESCR STD_AXIS NO_INPUT_QUANTITY m_uw_b6553p5 7 0.00 6553.500 FORMAT "%8.3" DEPOSIT ABSOLUTE /end AXIS_DESCR
 /begin AXIS_DESCR STD_AXIS HLSF.tasohf_w temp_q0p0234_o273 8 -273.1500 1262.827 FORMAT "%8.3" DEPOSIT ABSOLUTE /end AXIS_DESCR
/end CHARACTERISTIC
/begin CHARACTERISTIC HLSF.PHLSMN "" VALUE 0x802848E0 KwWU8 2.550 fak_q0p01 0.00 2.550 FORMAT "%5.3" /end CHARACTERISTIC
/begin CHARACTERISTIC HLSF.TASMN "" VALUE 0x802848E2 KwWU16 1535.977 temp_q0p0234_o273 -273.1500 1262.827 FORMAT "%8.3" /end CHARACTERISTIC
/begin CHARACTERISTIC HLSF.THSA "" VALUE 0x802848E4 KwWU8 25.50 t_q0p1 0.00 25.50 FORMAT "%5.2" /end CHARACTERISTIC
/begin CHARACTERISTIC HLSF.TPHLSMN "" VALUE 0x802848E5 KwWU8 25.50 t_q0p1 0.00 25.50 FORMAT "%5.2" /end CHARACTERISTIC
/begin CHARACTERISTIC HLSF.UHSOFF "" VALUE 0x802848E6 KwWU16 25.59961 spg_q0p00039 0.00 25.59961 FORMAT "%8.5" /end CHARACTERISTIC
/begin CHARACTERISTIC HLSF.ZKTASO "" CURVE 0x802848E8 KlAxU8SstxU16WU16 6553.4999985 zk100msxs_uw_b6553p6 0.10000152590 6553.6000000 FORMAT "%12.7"
 /begin AXIS_DESCR STD_AXIS NO_INPUT_QUANTITY m_uw_b6553p5 5 0.00 6553.500 FORMAT "%8.3" DEPOSIT ABSOLUTE /end AXIS_DESCR
/end CHARACTERISTIC
/begin CHARACTERISTIC HLSF2.CWHLS "" VALUE 0x80284904 KwWU8 255.0 dez 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC HLSF2.KFHSUSOL "" MAP 0x80284906 KfAxU8AyU8SstxU16SstyU16WU16 25.59961 spg_q0p00039 0.00 25.59961 FORMAT "%8.5"
 /begin AXIS_DESCR STD_AXIS NO_INPUT_QUANTITY m_uw_b6553p5 7 0.00 6553.500 FORMAT "%8.3" DEPOSIT ABSOLUTE /end AXIS_DESCR
 /begin AXIS_DESCR STD_AXIS HLSF2.tasohf_w temp_q0p0234_o273 8 -273.1500 1262.827 FORMAT "%8.3" DEPOSIT ABSOLUTE /end AXIS_DESCR
/end CHARACTERISTIC
/begin CHARACTERISTIC HLSF2.PHLSMN "" VALUE 0x80284998 KwWU8 2.550 fak_q0p01 0.00 2.550 FORMAT "%5.3" /end CHARACTERISTIC
/begin CHARACTERISTIC HLSF2.TASMN "" VALUE 0x8028499A KwWU16 1535.977 temp_q0p0234_o273 -273.1500 1262.827 FORMAT "%8.3" /end CHARACTERISTIC
/begin CHARACTERISTIC HLSF2.THSA "" VALUE 0x8028499C KwWU8 25.50 t_q0p1 0.00 25.50 FORMAT "%5.2" /end CHARACTERISTIC
/begin CHARACTERISTIC HLSF2.TPHLSMN "" VALUE 0x8028499D KwWU8 25.50 t_q0p1 0.00 25.50 FORMAT "%5.2" /end CHARACTERISTIC
/begin CHARACTERISTIC HLSF2.UHSOFF "" VALUE 0x8028499E KwWU16 25.59961 spg_q0p00039 0.00 25.59961 FORMAT "%8.5" /end CHARACTERISTIC
/begin CHARACTERISTIC HLSF2.ZKTASO "" CURVE 0x802849A0 KlAxU8SstxU16WU16 6553.4999985 zk100msxs_uw_b6553p6 0.10000152590 6553.6000000 FORMAT "%12.7"
 /begin AXIS_DESCR STD_AXIS NO_INPUT_QUANTITY m_uw_b6553p5 5 0.00 6553.500 FORMAT "%8.3" DEPOSIT ABSOLUTE /end AXIS_DESCR
/end CHARACTERISTIC
/begin CHARACTERISTIC HLSH.CWHLS "" VALUE 0x802849BC KwWU8 255.0 dez 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC HLSH.KFHSUSOL "" MAP 0x802849BE KfAxU8AyU8SstxU16SstyU16WU16 25.59961 spg_q0p00039 0.00 25.59961 FORMAT "%8.5"
 /begin AXIS_DESCR STD_AXIS NO_INPUT_QUANTITY m_uw_b6553p5 7 0.00 6553.500 FORMAT "%8.3" DEPOSIT ABSOLUTE /end AXIS_DESCR
 /begin AXIS_DESCR STD_AXIS HLSH.tasohf_w temp_q0p0234_o273 8 -273.1500 1262.827 FORMAT "%8.3" DEPOSIT ABSOLUTE /end AXIS_DESCR
/end CHARACTERISTIC
/begin CHARACTERISTIC HLSH.PHLSMN "" VALUE 0x80284A50 KwWU8 2.550 fak_q0p01 0.00 2.550 FORMAT "%5.3" /end CHARACTERISTIC
/begin CHARACTERISTIC HLSH.TASMN "" VALUE 0x80284A52 KwWU16 1535.977 temp_q0p0234_o273 -273.1500 1262.827 FORMAT "%8.3" /end CHARACTERISTIC
/begin CHARACTERISTIC HLSH.THSA "" VALUE 0x80284A54 KwWU8 25.50 t_q0p1 0.00 25.50 FORMAT "%5.2" /end CHARACTERISTIC
/begin CHARACTERISTIC HLSH.TPHLSMN "" VALUE 0x80284A55 KwWU8 25.50 t_q0p1 0.00 25.50 FORMAT "%5.2" /end CHARACTERISTIC
/begin CHARACTERISTIC HLSH.UHSOFF "" VALUE 0x80284A56 KwWU16 25.59961 spg_q0p00039 0.00 25.59961 FORMAT "%8.5" /end CHARACTERISTIC
/begin CHARACTERISTIC HLSH.ZKTASO "" CURVE 0x80284A58 KlAxU8SstxU16WU16 6553.4999985 zk100msxs_uw_b6553p6 0.10000152590 6553.6000000 FORMAT "%12.7"
 /begin AXIS_DESCR STD_AXIS NO_INPUT_QUANTITY m_uw_b6553p5 5 0.00 6553.500 FORMAT "%8.3" DEPOSIT ABSOLUTE /end AXIS_DESCR
/end CHARACTERISTIC
/begin CHARACTERISTIC HLSH2.CWHLS "" VALUE 0x80284A74 KwWU8 255.0 dez 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC HLSH2.KFHSUSOL "" MAP 0x80284A76 KfAxU8AyU8SstxU16SstyU16WU16 25.59961 spg_q0p00039 0.00 25.59961 FORMAT "%8.5"
 /begin AXIS_DESCR STD_AXIS NO_INPUT_QUANTITY m_uw_b6553p5 7 0.00 6553.500 FORMAT "%8.3" DEPOSIT ABSOLUTE /end AXIS_DESCR
 /begin AXIS_DESCR STD_AXIS HLSH2.tasohf_w temp_q0p0234_o273 8 -273.1500 1262.827 FORMAT "%8.3" DEPOSIT ABSOLUTE /end AXIS_DESCR
/end CHARACTERISTIC
/begin CHARACTERISTIC HLSH2.PHLSMN "" VALUE 0x80284B08 KwWU8 2.550 fak_q0p01 0.00 2.550 FORMAT "%5.3" /end CHARACTERISTIC
/begin CHARACTERISTIC HLSH2.TASMN "" VALUE 0x80284B0A KwWU16 1535.977 temp_q0p0234_o273 -273.1500 1262.827 FORMAT "%8.3" /end CHARACTERISTIC
/begin CHARACTERISTIC HLSH2.THSA "" VALUE 0x80284B0C KwWU8 25.50 t_q0p1 0.00 25.50 FORMAT "%5.2" /end CHARACTERISTIC
/begin CHARACTERISTIC HLSH2.TPHLSMN "" VALUE 0x80284B0D KwWU8 25.50 t_q0p1 0.00 25.50 FORMAT "%5.2" /end CHARACTERISTIC
/begin CHARACTERISTIC HLSH2.UHSOFF "" VALUE 0x80284B0E KwWU16 25.59961 spg_q0p00039 0.00 25.59961 FORMAT "%8.5" /end CHARACTERISTIC
/begin CHARACTERISTIC HLSH2.ZKTASO "" CURVE 0x80284B10 KlAxU8SstxU16WU16 6553.4999985 zk100msxs_uw_b6553p6 0.10000152590 6553.6000000 FORMAT "%12.7"
 /begin AXIS_DESCR STD_AXIS NO_INPUT_QUANTITY m_uw_b6553p5 5 0.00 6553.500 FORMAT "%8.3" DEPOSIT ABSOLUTE /end AXIS_DESCR
/end CHARACTERISTIC
/begin CHARACTERISTIC HLSV.CWHLS "" VALUE 0x80284B2C KwWU8 255.0 dez 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC HLSV.KFHSUSOL "" MAP 0x80284B2E KfAxU8AyU8SstxU16SstyU16WU16 25.59961 spg_q0p00039 0.00 25.59961 FORMAT "%8.5"
 /begin AXIS_DESCR STD_AXIS NO_INPUT_QUANTITY m_uw_b6553p5 7 0.00 6553.500 FORMAT "%8.3" DEPOSIT ABSOLUTE /end AXIS_DESCR
 /begin AXIS_DESCR STD_AXIS HLSV.tasohf_w temp_q0p0234_o273 8 -273.1500 1262.827 FORMAT "%8.3" DEPOSIT ABSOLUTE /end AXIS_DESCR
/end CHARACTERISTIC
/begin CHARACTERISTIC HLSV.PHLSMN "" VALUE 0x80284BC0 KwWU8 2.550 fak_q0p01 0.00 2.550 FORMAT "%5.3" /end CHARACTERISTIC
/begin CHARACTERISTIC HLSV.TASMN "" VALUE 0x80284BC2 KwWU16 1535.977 temp_q0p0234_o273 -273.1500 1262.827 FORMAT "%8.3" /end CHARACTERISTIC
/begin CHARACTERISTIC HLSV.THSA "" VALUE 0x80284BC4 KwWU8 25.50 t_q0p1 0.00 25.50 FORMAT "%5.2" /end CHARACTERISTIC
/begin CHARACTERISTIC HLSV.TPHLSMN "" VALUE 0x80284BC5 KwWU8 25.50 t_q0p1 0.00 25.50 FORMAT "%5.2" /end CHARACTERISTIC
/begin CHARACTERISTIC HLSV.UHSOFF "" VALUE 0x80284BC6 KwWU16 25.59961 spg_q0p00039 0.00 25.59961 FORMAT "%8.5" /end CHARACTERISTIC
/begin CHARACTERISTIC HLSV.ZKTASO "" CURVE 0x80284BC8 KlAxU8SstxU16WU16 6553.4999985 zk100msxs_uw_b6553p6 0.10000152590 6553.6000000 FORMAT "%12.7"
 /begin AXIS_DESCR STD_AXIS NO_INPUT_QUANTITY m_uw_b6553p5 5 0.00 6553.500 FORMAT "%8.3" DEPOSIT ABSOLUTE /end AXIS_DESCR
/end CHARACTERISTIC
/begin CHARACTERISTIC HLSV2.CWHLS "" VALUE 0x80284BE4 KwWU8 255.0 dez 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC HLSV2.KFHSUSOL "" MAP 0x80284BE6 KfAxU8AyU8SstxU16SstyU16WU16 25.59961 spg_q0p00039 0.00 25.59961 FORMAT "%8.5"
 /begin AXIS_DESCR STD_AXIS NO_INPUT_QUANTITY m_uw_b6553p5 7 0.00 6553.500 FORMAT "%8.3" DEPOSIT ABSOLUTE /end AXIS_DESCR
 /begin AXIS_DESCR STD_AXIS HLSV2.tasohf_w temp_q0p0234_o273 8 -273.1500 1262.827 FORMAT "%8.3" DEPOSIT ABSOLUTE /end AXIS_DESCR
/end CHARACTERISTIC
/begin CHARACTERISTIC HLSV2.PHLSMN "" VALUE 0x80284C78 KwWU8 2.550 fak_q0p01 0.00 2.550 FORMAT "%5.3" /end CHARACTERISTIC
/begin CHARACTERISTIC HLSV2.TASMN "" VALUE 0x80284C7A KwWU16 1535.977 temp_q0p0234_o273 -273.1500 1262.827 FORMAT "%8.3" /end CHARACTERISTIC
/begin CHARACTERISTIC HLSV2.THSA "" VALUE 0x80284C7C KwWU8 25.50 t_q0p1 0.00 25.50 FORMAT "%5.2" /end CHARACTERISTIC
/begin CHARACTERISTIC HLSV2.TPHLSMN "" VALUE 0x80284C7D KwWU8 25.50 t_q0p1 0.00 25.50 FORMAT "%5.2" /end CHARACTERISTIC
/begin CHARACTERISTIC HLSV2.UHSOFF "" VALUE 0x80284C7E KwWU16 25.59961 spg_q0p00039 0.00 25.59961 FORMAT "%8.5" /end CHARACTERISTIC
/begin CHARACTERISTIC HLSV2.ZKTASO "" CURVE 0x80284C80 KlAxU8SstxU16WU16 6553.4999985 zk100msxs_uw_b6553p6 0.10000152590 6553.6000000 FORMAT "%12.7"
 /begin AXIS_DESCR STD_AXIS NO_INPUT_QUANTITY m_uw_b6553p5 5 0.00 6553.500 FORMAT "%8.3" DEPOSIT ABSOLUTE /end AXIS_DESCR
/end CHARACTERISTIC
/begin CHARACTERISTIC I15031_nMaxSrv4_C "" VALUE 0x802B9914 Val_Ws16 10000.00 EngN 0.00 10000.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC I15031_PID1C_C "" VALUE 0x802B9916 Val_Wu8 28.0000000000 I15031_PID1CVerb 1.00000000000 29.0000000000 FORMAT "%13.10" /end CHARACTERISTIC
/begin CHARACTERISTIC I15031_PID4FA_C "" VALUE 0x802B9917 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC I15031_PID4FB_C "" VALUE 0x802B9918 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC I15031_PID4FC_C "" VALUE 0x802B9919 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC I15031_PID4FD_C "" VALUE 0x802B991A Val_Wu8 2550. OneToTenCarb 0.00 2550. FORMAT "%5.0" /end CHARACTERISTIC
/begin CHARACTERISTIC I15031_PID50A_C "" VALUE 0x802B991B Val_Wu8 2550. OneToTenCarb 0.00 2550. FORMAT "%5.0" /end CHARACTERISTIC
/begin CHARACTERISTIC I15031_PID5F_C "" VALUE 0x802B991C Val_Wu8 2.00000000000 I15031_PID5FVerb 14.0000000000 16.0000000000 FORMAT "%13.10" /end CHARACTERISTIC
/begin CHARACTERISTIC I15031_srv9PIDTable.PID0_C "" VALUE 0x802B991E Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC I15031_srv9PIDTable.PID1_C "" VALUE 0x802B991F Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC I15031_srv9PIDTable.PID2_C "" VALUE 0x802B9920 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC I15031_srv9PIDTable.PID3_C "" VALUE 0x802B9921 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC I15031_srv9PIDTable.PID4_C "" VALUE 0x802B9922 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC I15031_srv9PIDTable.PID5_C "" VALUE 0x802B9923 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC I15031_srv9PIDTable.PID6_C "" VALUE 0x802B9924 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC I15031_srv9PIDTable.PID7_C "" VALUE 0x802B9925 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC I15031_srv9PIDTable.PID8_C "" VALUE 0x802B9926 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC I15031_srv9PIDTable.PID9_C "" VALUE 0x802B9927 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC I15031_srv9PIDTable.PIDA_C "" VALUE 0x802B9928 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC I15031_srv9PIDTable.PIDB_C "" VALUE 0x802B9929 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC IgnClPs_Count "" VALUE 0x80284CD8 KwWU8 255.0 dez 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC IgnClPs_uBattMax_C "" VALUE 0x80284CDD KwWU8 25.50 spg_q0p1 0.00 25.50 FORMAT "%5.2" /end CHARACTERISTIC
/begin CHARACTERISTIC IgnClPs_uBattMin_C "" VALUE 0x80284CDE KwWU8 25.50 spg_q0p1 0.00 25.50 FORMAT "%5.2" /end CHARACTERISTIC
/begin CHARACTERISTIC Igndd_nrFolwUpSprk_C "" VALUE 0x80284CE3 KwWU8 1.000 dez 0.00 1.000 FORMAT "%5.3" /end CHARACTERISTIC
/begin CHARACTERISTIC Igndd_nrTypOfCl_C "" VALUE 0x80284CE4 KwWU8 1.000 dez 1.000 2.000 FORMAT "%5.3" /end CHARACTERISTIC
/begin CHARACTERISTIC IMLNAMN "" VALUE 0x802843D0 KwWU16 1.820417 m_q2p777Em5_kg 0.00 1.820417 FORMAT "%8.6" /end CHARACTERISTIC
/begin CHARACTERISTIC IMLNAMN2 "" VALUE 0x802843D2 KwWU16 1.820417 m_q2p777Em5_kg 0.00 1.820417 FORMAT "%8.6" /end CHARACTERISTIC
/begin CHARACTERISTIC injdd_InjTypeFuelMode_C "Fuel Injection Type Selection(GDI or PFI)" VALUE 0x802843BA KwUb 1.00000000000 injdd_InjTypeFuelMode_State_t 0.00 1.00000000000 FORMAT "%13.11" /end CHARACTERISTIC
/begin CHARACTERISTIC INJVLVPS_DCEN2_C "" VALUE 0x80284CFC KwUb 1.000 dez 0.00 1.000 FORMAT "%5.3" /end CHARACTERISTIC
/begin CHARACTERISTIC INJVLVPS_DCTM2_C "" VALUE 0x80284CFE KwUb 1.000 dez 0.00 1.000 FORMAT "%5.3" /end CHARACTERISTIC
/begin CHARACTERISTIC INJVLVPS_ENLS2_C "" VALUE 0x80284D00 KwUb 15.00 dez 0.00 15.00 FORMAT "%5.2" /end CHARACTERISTIC
/begin CHARACTERISTIC INJVLVPS_MSV2_C "" VALUE 0x80284D09 KwUb 1.000 dez 0.00 1.000 FORMAT "%5.3" /end CHARACTERISTIC
/begin CHARACTERISTIC IPREFLIM "" VALUE 0x80284758 KwWU8 255.0 dez 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC IsoTp_xCAN1ProgRxMsgID_C "" VALUE 0x80282638 Val_Wu32 4294967295.00 OneToOne 0.00 4294967295.00 FORMAT "%13.2" /end CHARACTERISTIC
/begin CHARACTERISTIC IsoTp_xCAN1ProgTxMsgID_C "" VALUE 0x80282634 Val_Wu32 4294967295.00 OneToOne 0.00 4294967295.00 FORMAT "%13.2" /end CHARACTERISTIC
/begin CHARACTERISTIC IsoTp_xCAN2ProgRxMsgID_C "" VALUE 0x80282630 Val_Wu32 4294967295.00 OneToOne 0.00 4294967295.00 FORMAT "%13.2" /end CHARACTERISTIC
/begin CHARACTERISTIC IsoTp_xCAN2ProgTxMsgID_C "" VALUE 0x8028262C Val_Wu32 4294967295.00 OneToOne 0.00 4294967295.00 FORMAT "%13.2" /end CHARACTERISTIC
/begin CHARACTERISTIC IsoTp_xKWPRxMsgID_C "" VALUE 0x80282628 Val_Wu32 4294967295.00 OneToOne 0.00 4294967295.00 FORMAT "%13.2" /end CHARACTERISTIC
/begin CHARACTERISTIC IsoTp_xKWPTxMsgID_C "" VALUE 0x80282624 Val_Wu32 4294967295.00 OneToOne 0.00 4294967295.00 FORMAT "%13.2" /end CHARACTERISTIC
/begin CHARACTERISTIC IsoTP_xUDSStdFastRxMsgID_C "" VALUE 0x80282620 Val_Wu32 4294967295.00 OneToOne 0.00 4294967295.00 FORMAT "%13.2" /end CHARACTERISTIC
/begin CHARACTERISTIC IsoTP_xUDSStdFastTxMsgID_C "" VALUE 0x8028261C Val_Wu32 4294967295.00 OneToOne 0.00 4294967295.00 FORMAT "%13.2" /end CHARACTERISTIC
/begin CHARACTERISTIC IsoTP_xUDSStdRxMsgID_C "" VALUE 0x80282618 Val_Wu32 4294967295.00 OneToOne 0.00 4294967295.00 FORMAT "%13.2" /end CHARACTERISTIC
/begin CHARACTERISTIC IsoTP_xUDSStdTxMsgID_C "" VALUE 0x80282614 Val_Wu32 4294967295.00 OneToOne 0.00 4294967295.00 FORMAT "%13.2" /end CHARACTERISTIC
/begin CHARACTERISTIC KFRFIL "" VALUE 0x802843D4 KwWU16 65.534999985 zk1msxs_uw_b65p536 0.0010000152590 65.536000000 FORMAT "%12.9" /end CHARACTERISTIC
/begin CHARACTERISTIC KLIMLNA "" CURVE 0x802843D6 KlAxU8SstxU16WU16 6553.4999985 zk100msxs_uw_b6553p6 0.10000152590 6553.6000000 FORMAT "%12.7"
 /begin AXIS_DESCR STD_AXIS NO_INPUT_QUANTITY fak_uw_b16 5 0.00 15.99976 FORMAT "%8.5" DEPOSIT ABSOLUTE /end AXIS_DESCR
/end CHARACTERISTIC
/begin CHARACTERISTIC KLRTLSU_flex "" CURVE 0x80284346 KlAxU8SstxU16WU16 1535.977 temp_q0p0234_o273 -273.1500 1262.827 FORMAT "%8.3"
 /begin AXIS_DESCR STD_AXIS NO_INPUT_QUANTITY r_q0p15625 22 0.00 10239.84 FORMAT "%8.2" DEPOSIT ABSOLUTE /end AXIS_DESCR
/end CHARACTERISTIC
/begin CHARACTERISTIC KLSHTHE "" CURVE 0x802847DE KlAxU8SstxU16WU16 6553.500 t_q0p1 0.00 6553.500 FORMAT "%8.3"
 /begin AXIS_DESCR STD_AXIS NO_INPUT_QUANTITY t_q0p1 5 0.00 6553.500 FORMAT "%8.3" DEPOSIT ABSOLUTE /end AXIS_DESCR
/end CHARACTERISTIC
/begin CHARACTERISTIC KLTABSTHE "" CURVE 0x802847F4 KlAxU8SstxU16WU16 6553.500 t_q0p1 0.00 6553.500 FORMAT "%8.3"
 /begin AXIS_DESCR STD_AXIS tabst_w t_q1 5 0.00 65535.00 FORMAT "%8.2" DEPOSIT ABSOLUTE /end AXIS_DESCR
/end CHARACTERISTIC
/begin CHARACTERISTIC KnDet_cntKnSens_C "" VALUE 0x80284FB0 KwUb 255.0 dez 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC KnDet_CoefFlt_CA "" VAL_BLK 0x80284D68 KwbUw 65535.00 dez 0.00 65535.00 FORMAT "%8.2" NUMBER 292 /end CHARACTERISTIC
/begin CHARACTERISTIC KnDet_SensMaxErr_C "" VALUE 0x80284D60 KwSw 6.599899 spg_sw_q0p0001 -3.300000 3.299899 FORMAT "%8.6" /end CHARACTERISTIC
/begin CHARACTERISTIC KnDet_SensMinErr_C "" VALUE 0x80284D62 KwSw 6.599899 spg_sw_q0p0001 -3.300000 3.299899 FORMAT "%8.6" /end CHARACTERISTIC
/begin CHARACTERISTIC KnDet_ThresNGradMeasWin_C "" VALUE 0x80284D5A KwSw 10000.00 EngNGrd 0.00 10000.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC KnDet_ThresNMeasWin_C "" VALUE 0x80284D5C KwSw 10000.00 nmot_q0p5 0.00 10000.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC KnDet_ThresNumMeasWin_C "" VALUE 0x80284D5E KwSw 50.00000 dez 0.00 50.00000 FORMAT "%8.5" /end CHARACTERISTIC
/begin CHARACTERISTIC KRIVKMX "" VALUE 0x802843EC KwWU16 2559.961 r_q0p0391 0.00 2559.961 FORMAT "%8.3" /end CHARACTERISTIC
/begin CHARACTERISTIC KUSVKMX "" VALUE 0x802843EE KwWS16 31.99951 spg_q4p88Em4 -16.00000 15.99951 FORMAT "%8.5" /end CHARACTERISTIC
/begin CHARACTERISTIC LABIP "" CURVE 0x80284688 KlAxU8SstxS16WU16 15.99976 fak_uw_b16 0.00 15.99976 FORMAT "%8.5"
 /begin AXIS_DESCR STD_AXIS NO_INPUT_QUANTITY i_q1_uA 25 -32768.00 32767.00 FORMAT "%8.2" DEPOSIT ABSOLUTE /end AXIS_DESCR
/end CHARACTERISTIC
/begin CHARACTERISTIC LABIP_flex "" CURVE 0x802B9950 KlAxU8SstxS16WU16 15.99976 fak_uw_b16 0.00 15.99976 FORMAT "%8.5"
 /begin AXIS_DESCR STD_AXIS NO_INPUT_QUANTITY i_q1_uA 25 -32768.00 32767.00 FORMAT "%8.2" DEPOSIT ABSOLUTE /end AXIS_DESCR
/end CHARACTERISTIC
/begin CHARACTERISTIC LAMSSMN "" VALUE 0x802843F0 KwWU16 15.99976 fak_uw_b16 0.00 15.99976 FORMAT "%8.5" /end CHARACTERISTIC
/begin CHARACTERISTIC LAMSSMX "" VALUE 0x802843F2 KwWU16 15.99976 fak_uw_b16 0.00 15.99976 FORMAT "%8.5" /end CHARACTERISTIC
/begin CHARACTERISTIC LSF_4_2_Threshold_C "" VALUE 0x802B99B6 Val_Ws16 13107.00 Volt -6553.600 6553.400 FORMAT "%8.3" /end CHARACTERISTIC
/begin CHARACTERISTIC LSU_facUToRi_C "" VALUE 0x802B99B8 Val_Ws16 32.76750 VoltToRes -16.38400 16.38350 FORMAT "%8.5" /end CHARACTERISTIC
/begin CHARACTERISTIC LSU_rLamRec_CUR "" CURVE 0x802B99BA Cur_Xs16Ws16 65.53500 lambdaRecVal -32.76800 32.76700 FORMAT "%8.5"
 /begin AXIS_DESCR STD_AXIS NO_INPUT_QUANTITY lambdaRecVal 12 -32.76800 32.76700 FORMAT "%8.5" DEPOSIT ABSOLUTE /end AXIS_DESCR
/end CHARACTERISTIC
/begin CHARACTERISTIC LSU_rO2TransfUA1_CUR "" CURVE 0x802B99EC Cur_Xs16Ws16 0.6553500 O2 -0.3276800 0.3276700 FORMAT "%9.7"
 /begin AXIS_DESCR STD_AXIS LSU_uRawAdcUA1_mp Volt 15 -6553.600 6553.400 FORMAT "%8.3" DEPOSIT ABSOLUTE /end AXIS_DESCR
/end CHARACTERISTIC
/begin CHARACTERISTIC LSU_rO2TransfUA2_CUR "" CURVE 0x802B9A2A Cur_Xs16Ws16 0.6553500 O2 -0.3276800 0.3276700 FORMAT "%9.7"
 /begin AXIS_DESCR STD_AXIS LSU_uRawAdcUA2_mp Volt 15 -6553.600 6553.400 FORMAT "%8.3" DEPOSIT ABSOLUTE /end AXIS_DESCR
/end CHARACTERISTIC
/begin CHARACTERISTIC LSU_tRiUR1_CUR "" CURVE 0x802B9A68 Cur_Xs16Ws16 1200.000 Temp_Cels 99.96000 1299.960 FORMAT "%8.3"
 /begin AXIS_DESCR STD_AXIS LSU_uRawAdcUR1_mp Volt 16 0.00 3000.000 FORMAT "%8.3" DEPOSIT ABSOLUTE /end AXIS_DESCR
/end CHARACTERISTIC
/begin CHARACTERISTIC LSU_tRi_CUR "" CURVE 0x802B9AAA Cur_Xs16Ws16 1200.000 Temp_Cels 99.96000 1299.960 FORMAT "%8.3"
 /begin AXIS_DESCR STD_AXIS LSU_uRawAdcUR2_mp Volt 16 0.00 3000.000 FORMAT "%8.3" DEPOSIT ABSOLUTE /end AXIS_DESCR
/end CHARACTERISTIC
/begin CHARACTERISTIC LSU_uO2RefUA_C "" VALUE 0x802B9AEC Val_Ws16 5000.000 Volt 0.00 5000.000 FORMAT "%8.3" /end CHARACTERISTIC
/begin CHARACTERISTIC LSU_uO2RefUR_C "" VALUE 0x802B9AEE Val_Ws16 5000.000 Volt 0.00 5000.000 FORMAT "%8.3" /end CHARACTERISTIC
/begin CHARACTERISTIC LSU_uO2Ref_C "" VALUE 0x802B9AF0 Val_Ws16 13107.00 Volt -6553.600 6553.400 FORMAT "%8.3" /end CHARACTERISTIC
/begin CHARACTERISTIC medc_datasetid "" ASCII 0x802B94B2 ValA_Wu8 255.0 defaultAscii 0.00 255.0 NUMBER 99 /end CHARACTERISTIC
/begin CHARACTERISTIC Mfdd_MSVCamMntg_C "" VALUE 0x80284FE1 KwWU8 4.000 dez 0.00 4.000 FORMAT "%5.3" /end CHARACTERISTIC
/begin CHARACTERISTIC Mfdd_numLobes_C "The camlobe profile on which is High Pressure Pump is mounted" VALUE 0x80284FE2 KwWU8 2.000 dez 2.000 4.000 FORMAT "%5.3" /end CHARACTERISTIC
/begin CHARACTERISTIC MFDD_phiHDP2_C "Delta angle between the first and the second High pressure pump." VALUE 0x80284FE4 KwWS16 6553.500 kw_q0p1 -3276.800 3276.700 FORMAT "%8.3" /end CHARACTERISTIC
/begin CHARACTERISTIC MFDD_phiOTZ1OTP_CA "Differential angle between the TDC of cylinder 1 and the TDC of the Pump" VAL_BLK 0x80284FE6 KwbWS16 720.0000 kw_q1 -360.0000 360.0000 FORMAT "%8.4" NUMBER 1 /end CHARACTERISTIC
/begin CHARACTERISTIC Mfpsdia_uBattMax_C "" VALUE 0x80284FEF KwWU8 25.50 spg_q0p1 0.00 25.50 FORMAT "%5.2" /end CHARACTERISTIC
/begin CHARACTERISTIC Mfpsdia_uBattMin_C "" VALUE 0x80284FF0 KwWU8 25.50 spg_q0p1 0.00 25.50 FORMAT "%5.2" /end CHARACTERISTIC
/begin CHARACTERISTIC MfVlv_nEngMaxHot_C "" VALUE 0x80285066 KwWU8 10200. nmot_ub_q40 0.00 10200. FORMAT "%5.0" /end CHARACTERISTIC
/begin CHARACTERISTIC MILLmp_stMILCfg_CW "" VALUE 0x802B992A Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC MILLmp_tiAftStrt_C "" VALUE 0x802B992B Val_Wu8 254.0 t1sxs_q1 1.000 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC MILLmp_tiRdnBln_C "" VALUE 0x802B992C Val_Wu8 5.000 t1sxs_q1 5.000 10.00 FORMAT "%5.2" /end CHARACTERISTIC
/begin CHARACTERISTIC MILLmp_tiVisTst_C "" VALUE 0x802B992D Val_Wu8 5.000 t1sxs_q1 15.00 20.00 FORMAT "%5.2" /end CHARACTERISTIC
/begin CHARACTERISTIC MRly_ctErlyOpng_C "" VALUE 0x802B992E Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC MRly_tiStkRlyDiaDel_C "" VALUE 0x802B9930 Val_Ws16 3000.000 Time_ms 0.00 3000.000 FORMAT "%8.3" /end CHARACTERISTIC
/begin CHARACTERISTIC NGDSMPLMX "" VALUE 0x802843F4 KwWU8 11.00 dez 0.00 11.00 FORMAT "%5.2" /end CHARACTERISTIC
/begin CHARACTERISTIC NRIIPREF "" VALUE 0x802847BA KwWU16 65535.00 dez 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_DC1_Pwm.tiPer_C "" VALUE 0x802B9616 Kw_Ws16 32766.00 Time_usec_q1_COMPU 1.000000 32767.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_DC1_Pwm.stLvl_C "" VALUE 0x802B9618 Kw_Wu8 3.000 OneToOne 0.00 3.000 FORMAT "%5.3" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_DC1_Pwm.rMaxDty_C "" VALUE 0x802B961A Kw_Ws16 10000.00 OneToOne 0.00 10000.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_DC1_Pwm.rPerUn_C "" VALUE 0x802B961C Kw_Ws16 32766.00 Time_usec_q1_COMPU 1.000000 32767.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_DC1_Pwm.tiPh_C "" VALUE 0x802B961E Kw_Ws16 65535.00 OneToOne -32768.00 32767.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_DC2_Pwm.tiPer_C "" VALUE 0x802B9620 Kw_Ws16 32766.00 Time_usec_q1_COMPU 1.000000 32767.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_DC2_Pwm.stLvl_C "" VALUE 0x802B9622 Kw_Wu8 3.000 OneToOne 0.00 3.000 FORMAT "%5.3" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_DC2_Pwm.rMaxDty_C "" VALUE 0x802B9624 Kw_Ws16 10000.00 OneToOne 0.00 10000.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_DC2_Pwm.rPerUn_C "" VALUE 0x802B9626 Kw_Ws16 32766.00 Time_usec_q1_COMPU 1.000000 32767.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_DC2_Pwm.tiPh_C "" VALUE 0x802B9628 Kw_Ws16 65535.00 OneToOne -32768.00 32767.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_DC3_Pwm.tiPer_C "" VALUE 0x802B962A Kw_Ws16 32766.00 Time_usec_q1_COMPU 1.000000 32767.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_DC3_Pwm.stLvl_C "" VALUE 0x802B962C Kw_Wu8 3.000 OneToOne 0.00 3.000 FORMAT "%5.3" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_DC3_Pwm.rMaxDty_C "" VALUE 0x802B962E Kw_Ws16 10000.00 OneToOne 0.00 10000.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_DC3_Pwm.rPerUn_C "" VALUE 0x802B9630 Kw_Ws16 32766.00 Time_usec_q1_COMPU 1.000000 32767.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_DC3_Pwm.tiPh_C "" VALUE 0x802B9632 Kw_Ws16 65535.00 OneToOne -32768.00 32767.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_RH02_Pwm.tiPer_C "" VALUE 0x802B9634 Kw_Ws16 32766.00 Time_usec_q1_COMPU 1.000000 32767.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_RH02_Pwm.stLvl_C "" VALUE 0x802B9636 Kw_Wu8 3.000 OneToOne 0.00 3.000 FORMAT "%5.3" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_RH02_Pwm.rMaxDty_C "" VALUE 0x802B9638 Kw_Ws16 10000.00 OneToOne 0.00 10000.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_RH02_Pwm.rPerUn_C "" VALUE 0x802B963A Kw_Ws16 32766.00 Time_usec_q1_COMPU 1.000000 32767.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_RH02_Pwm.tiPh_C "" VALUE 0x802B963C Kw_Ws16 65535.00 OneToOne -32768.00 32767.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_RL10_Pwm.tiPer_C "" VALUE 0x802B963E Kw_Ws16 32766.00 Time_usec_q1_COMPU 1.000000 32767.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_RL10_Pwm.stLvl_C "" VALUE 0x802B9640 Kw_Wu8 3.000 OneToOne 0.00 3.000 FORMAT "%5.3" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_RL10_Pwm.rMaxDty_C "" VALUE 0x802B9642 Kw_Ws16 10000.00 OneToOne 0.00 10000.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_RL10_Pwm.rPerUn_C "" VALUE 0x802B9644 Kw_Ws16 32766.00 Time_usec_q1_COMPU 1.000000 32767.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_RL10_Pwm.tiPh_C "" VALUE 0x802B9646 Kw_Ws16 65535.00 OneToOne -32768.00 32767.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_RL13_Pwm.tiPer_C "" VALUE 0x802B9648 Kw_Ws16 32766.00 Time_usec_q1_COMPU 1.000000 32767.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_RL13_Pwm.stLvl_C "" VALUE 0x802B964A Kw_Wu8 3.000 OneToOne 0.00 3.000 FORMAT "%5.3" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_RL13_Pwm.rMaxDty_C "" VALUE 0x802B964C Kw_Ws16 10000.00 OneToOne 0.00 10000.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_RL13_Pwm.rPerUn_C "" VALUE 0x802B964E Kw_Ws16 32766.00 Time_usec_q1_COMPU 1.000000 32767.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_RL13_Pwm.tiPh_C "" VALUE 0x802B9650 Kw_Ws16 65535.00 OneToOne -32768.00 32767.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_RL19_Pwm.tiPer_C "" VALUE 0x802B9652 Kw_Ws16 32766.00 Time_usec_q1_COMPU 1.000000 32767.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_RL19_Pwm.stLvl_C "" VALUE 0x802B9654 Kw_Wu8 3.000 OneToOne 0.00 3.000 FORMAT "%5.3" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_RL19_Pwm.rMaxDty_C "" VALUE 0x802B9656 Kw_Ws16 10000.00 OneToOne 0.00 10000.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_RL19_Pwm.rPerUn_C "" VALUE 0x802B9658 Kw_Ws16 32766.00 Time_usec_q1_COMPU 1.000000 32767.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_RL19_Pwm.tiPh_C "" VALUE 0x802B965A Kw_Ws16 65535.00 OneToOne -32768.00 32767.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_RL20_Pwm.tiPer_C "" VALUE 0x802B965C Kw_Ws16 32766.00 Time_usec_q1_COMPU 1.000000 32767.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_RL20_Pwm.stLvl_C "" VALUE 0x802B965E Kw_Wu8 3.000 OneToOne 0.00 3.000 FORMAT "%5.3" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_RL20_Pwm.rMaxDty_C "" VALUE 0x802B9660 Kw_Ws16 10000.00 OneToOne 0.00 10000.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_RL20_Pwm.rPerUn_C "" VALUE 0x802B9662 Kw_Ws16 32766.00 Time_usec_q1_COMPU 1.000000 32767.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_RL20_Pwm.tiPh_C "" VALUE 0x802B9664 Kw_Ws16 65535.00 OneToOne -32768.00 32767.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_RL22_Pwm.tiPer_C "" VALUE 0x802B9666 Kw_Ws16 32766.00 Time_usec_q1_COMPU 1.000000 32767.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_RL22_Pwm.stLvl_C "" VALUE 0x802B9668 Kw_Wu8 3.000 OneToOne 0.00 3.000 FORMAT "%5.3" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_RL22_Pwm.rMaxDty_C "" VALUE 0x802B966A Kw_Ws16 10000.00 OneToOne 0.00 10000.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_RL22_Pwm.rPerUn_C "" VALUE 0x802B966C Kw_Ws16 32766.00 Time_usec_q1_COMPU 1.000000 32767.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_RL22_Pwm.tiPh_C "" VALUE 0x802B966E Kw_Ws16 65535.00 OneToOne -32768.00 32767.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_RL23_Pwm.tiPer_C "" VALUE 0x802B9670 Kw_Ws16 32766.00 Time_usec_q1_COMPU 1.000000 32767.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_RL23_Pwm.stLvl_C "" VALUE 0x802B9672 Kw_Wu8 3.000 OneToOne 0.00 3.000 FORMAT "%5.3" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_RL23_Pwm.rMaxDty_C "" VALUE 0x802B9674 Kw_Ws16 10000.00 OneToOne 0.00 10000.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_RL23_Pwm.rPerUn_C "" VALUE 0x802B9676 Kw_Ws16 32766.00 Time_usec_q1_COMPU 1.000000 32767.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_RL23_Pwm.tiPh_C "" VALUE 0x802B9678 Kw_Ws16 65535.00 OneToOne -32768.00 32767.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_RL25_Pwm.tiPer_C "" VALUE 0x802B967A Kw_Ws16 32766.00 Time_usec_q1_COMPU 1.000000 32767.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_RL25_Pwm.stLvl_C "" VALUE 0x802B967C Kw_Wu8 3.000 OneToOne 0.00 3.000 FORMAT "%5.3" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_RL25_Pwm.rMaxDty_C "" VALUE 0x802B967E Kw_Ws16 10000.00 OneToOne 0.00 10000.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_RL25_Pwm.rPerUn_C "" VALUE 0x802B9680 Kw_Ws16 32766.00 Time_usec_q1_COMPU 1.000000 32767.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_RL25_Pwm.tiPh_C "" VALUE 0x802B9682 Kw_Ws16 65535.00 OneToOne -32768.00 32767.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_RL26_Pwm.tiPer_C "" VALUE 0x802B9684 Kw_Ws16 32766.00 Time_usec_q1_COMPU 1.000000 32767.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_RL26_Pwm.stLvl_C "" VALUE 0x802B9686 Kw_Wu8 3.000 OneToOne 0.00 3.000 FORMAT "%5.3" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_RL26_Pwm.rMaxDty_C "" VALUE 0x802B9688 Kw_Ws16 10000.00 OneToOne 0.00 10000.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_RL26_Pwm.rPerUn_C "" VALUE 0x802B968A Kw_Ws16 32766.00 Time_usec_q1_COMPU 1.000000 32767.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_RL26_Pwm.tiPh_C "" VALUE 0x802B968C Kw_Ws16 65535.00 OneToOne -32768.00 32767.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_RL27_Pwm.tiPer_C "" VALUE 0x802B968E Kw_Ws16 32766.00 Time_usec_q1_COMPU 1.000000 32767.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_RL27_Pwm.stLvl_C "" VALUE 0x802B9690 Kw_Wu8 3.000 OneToOne 0.00 3.000 FORMAT "%5.3" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_RL27_Pwm.rMaxDty_C "" VALUE 0x802B9692 Kw_Ws16 10000.00 OneToOne 0.00 10000.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_RL27_Pwm.rPerUn_C "" VALUE 0x802B9694 Kw_Ws16 32766.00 Time_usec_q1_COMPU 1.000000 32767.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_RL27_Pwm.tiPh_C "" VALUE 0x802B9696 Kw_Ws16 65535.00 OneToOne -32768.00 32767.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_RL28_Pwm.tiPer_C "" VALUE 0x802B9698 Kw_Ws16 32766.00 Time_usec_q1_COMPU 1.000000 32767.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_RL28_Pwm.stLvl_C "" VALUE 0x802B969A Kw_Wu8 3.000 OneToOne 0.00 3.000 FORMAT "%5.3" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_RL28_Pwm.rMaxDty_C "" VALUE 0x802B969C Kw_Ws16 10000.00 OneToOne 0.00 10000.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_RL28_Pwm.rPerUn_C "" VALUE 0x802B969E Kw_Ws16 32766.00 Time_usec_q1_COMPU 1.000000 32767.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_RL28_Pwm.tiPh_C "" VALUE 0x802B96A0 Kw_Ws16 65535.00 OneToOne -32768.00 32767.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_RL38_Pwm.tiPer_C "" VALUE 0x802B96A2 Kw_Ws16 32766.00 Time_usec_q1_COMPU 1.000000 32767.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_RL38_Pwm.stLvl_C "" VALUE 0x802B96A4 Kw_Wu8 3.000 OneToOne 0.00 3.000 FORMAT "%5.3" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_RL38_Pwm.rMaxDty_C "" VALUE 0x802B96A6 Kw_Ws16 10000.00 OneToOne 0.00 10000.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_RL38_Pwm.rPerUn_C "" VALUE 0x802B96A8 Kw_Ws16 32766.00 Time_usec_q1_COMPU 1.000000 32767.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_RL38_Pwm.tiPh_C "" VALUE 0x802B96AA Kw_Ws16 65535.00 OneToOne -32768.00 32767.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_RL39_Pwm.tiPer_C "" VALUE 0x802B96AC Kw_Ws16 32766.00 Time_usec_q1_COMPU 1.000000 32767.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_RL39_Pwm.stLvl_C "" VALUE 0x802B96AE Kw_Wu8 3.000 OneToOne 0.00 3.000 FORMAT "%5.3" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_RL39_Pwm.rMaxDty_C "" VALUE 0x802B96B0 Kw_Ws16 10000.00 OneToOne 0.00 10000.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_RL39_Pwm.rPerUn_C "" VALUE 0x802B96B2 Kw_Ws16 32766.00 Time_usec_q1_COMPU 1.000000 32767.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_RL39_Pwm.tiPh_C "" VALUE 0x802B96B4 Kw_Ws16 65535.00 OneToOne -32768.00 32767.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_RL40_Pwm.tiPer_C "" VALUE 0x802B96B6 Kw_Ws16 32766.00 Time_usec_q1_COMPU 1.000000 32767.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_RL40_Pwm.stLvl_C "" VALUE 0x802B96B8 Kw_Wu8 3.000 OneToOne 0.00 3.000 FORMAT "%5.3" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_RL40_Pwm.rMaxDty_C "" VALUE 0x802B96BA Kw_Ws16 10000.00 OneToOne 0.00 10000.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_RL40_Pwm.rPerUn_C "" VALUE 0x802B96BC Kw_Ws16 32766.00 Time_usec_q1_COMPU 1.000000 32767.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_RL40_Pwm.tiPh_C "" VALUE 0x802B96BE Kw_Ws16 65535.00 OneToOne -32768.00 32767.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_RL42_Pwm.tiPer_C "" VALUE 0x802B96C0 Kw_Ws16 32766.00 Time_usec_q1_COMPU 1.000000 32767.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_RL42_Pwm.stLvl_C "" VALUE 0x802B96C2 Kw_Wu8 3.000 OneToOne 0.00 3.000 FORMAT "%5.3" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_RL42_Pwm.rMaxDty_C "" VALUE 0x802B96C4 Kw_Ws16 10000.00 OneToOne 0.00 10000.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_RL42_Pwm.rPerUn_C "" VALUE 0x802B96C6 Kw_Ws16 32766.00 Time_usec_q1_COMPU 1.000000 32767.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_RL42_Pwm.tiPh_C "" VALUE 0x802B96C8 Kw_Ws16 65535.00 OneToOne -32768.00 32767.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_RL44_Pwm.tiPer_C "" VALUE 0x802B96CA Kw_Ws16 32766.00 Time_usec_q1_COMPU 1.000000 32767.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_RL44_Pwm.stLvl_C "" VALUE 0x802B96CC Kw_Wu8 3.000 OneToOne 0.00 3.000 FORMAT "%5.3" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_RL44_Pwm.rMaxDty_C "" VALUE 0x802B96CE Kw_Ws16 10000.00 OneToOne 0.00 10000.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_RL44_Pwm.rPerUn_C "" VALUE 0x802B96D0 Kw_Ws16 32766.00 Time_usec_q1_COMPU 1.000000 32767.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_RL44_Pwm.tiPh_C "" VALUE 0x802B96D2 Kw_Ws16 65535.00 OneToOne -32768.00 32767.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_RL45_Pwm.tiPer_C "" VALUE 0x802B96D4 Kw_Ws16 32766.00 Time_usec_q1_COMPU 1.000000 32767.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_RL45_Pwm.stLvl_C "" VALUE 0x802B96D6 Kw_Wu8 3.000 OneToOne 0.00 3.000 FORMAT "%5.3" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_RL45_Pwm.rMaxDty_C "" VALUE 0x802B96D8 Kw_Ws16 10000.00 OneToOne 0.00 10000.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_RL45_Pwm.rPerUn_C "" VALUE 0x802B96DA Kw_Ws16 32766.00 Time_usec_q1_COMPU 1.000000 32767.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_RL45_Pwm.tiPh_C "" VALUE 0x802B96DC Kw_Ws16 65535.00 OneToOne -32768.00 32767.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_RL46_Pwm.tiPer_C "" VALUE 0x802B96DE Kw_Ws16 32766.00 Time_usec_q1_COMPU 1.000000 32767.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_RL46_Pwm.stLvl_C "" VALUE 0x802B96E0 Kw_Wu8 3.000 OneToOne 0.00 3.000 FORMAT "%5.3" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_RL46_Pwm.rMaxDty_C "" VALUE 0x802B96E2 Kw_Ws16 10000.00 OneToOne 0.00 10000.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_RL46_Pwm.rPerUn_C "" VALUE 0x802B96E4 Kw_Ws16 32766.00 Time_usec_q1_COMPU 1.000000 32767.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_RL46_Pwm.tiPh_C "" VALUE 0x802B96E6 Kw_Ws16 65535.00 OneToOne -32768.00 32767.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_RL47_Pwm.tiPer_C "" VALUE 0x802B96E8 Kw_Ws16 32766.00 Time_usec_q1_COMPU 1.000000 32767.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_RL47_Pwm.stLvl_C "" VALUE 0x802B96EA Kw_Wu8 3.000 OneToOne 0.00 3.000 FORMAT "%5.3" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_RL47_Pwm.rMaxDty_C "" VALUE 0x802B96EC Kw_Ws16 10000.00 OneToOne 0.00 10000.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_RL47_Pwm.rPerUn_C "" VALUE 0x802B96EE Kw_Ws16 32766.00 Time_usec_q1_COMPU 1.000000 32767.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_RL47_Pwm.tiPh_C "" VALUE 0x802B96F0 Kw_Ws16 65535.00 OneToOne -32768.00 32767.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_RL48_Pwm.tiPer_C "" VALUE 0x802B96F2 Kw_Ws16 32766.00 Time_usec_q1_COMPU 1.000000 32767.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_RL48_Pwm.stLvl_C "" VALUE 0x802B96F4 Kw_Wu8 3.000 OneToOne 0.00 3.000 FORMAT "%5.3" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_RL48_Pwm.rMaxDty_C "" VALUE 0x802B96F6 Kw_Ws16 10000.00 OneToOne 0.00 10000.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_RL48_Pwm.rPerUn_C "" VALUE 0x802B96F8 Kw_Ws16 32766.00 Time_usec_q1_COMPU 1.000000 32767.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_RL48_Pwm.tiPh_C "" VALUE 0x802B96FA Kw_Ws16 65535.00 OneToOne -32768.00 32767.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_RL49_Pwm.tiPer_C "" VALUE 0x802B96FC Kw_Ws16 32766.00 Time_usec_q1_COMPU 1.000000 32767.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_RL49_Pwm.stLvl_C "" VALUE 0x802B96FE Kw_Wu8 3.000 OneToOne 0.00 3.000 FORMAT "%5.3" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_RL49_Pwm.rMaxDty_C "" VALUE 0x802B9700 Kw_Ws16 10000.00 OneToOne 0.00 10000.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_RL49_Pwm.rPerUn_C "" VALUE 0x802B9702 Kw_Ws16 32766.00 Time_usec_q1_COMPU 1.000000 32767.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_RL49_Pwm.tiPh_C "" VALUE 0x802B9704 Kw_Ws16 65535.00 OneToOne -32768.00 32767.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_RL50_Pwm.tiPer_C "" VALUE 0x802B9706 Kw_Ws16 32766.00 Time_usec_q1_COMPU 1.000000 32767.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_RL50_Pwm.stLvl_C "" VALUE 0x802B9708 Kw_Wu8 3.000 OneToOne 0.00 3.000 FORMAT "%5.3" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_RL50_Pwm.rMaxDty_C "" VALUE 0x802B970A Kw_Ws16 10000.00 OneToOne 0.00 10000.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_RL50_Pwm.rPerUn_C "" VALUE 0x802B970C Kw_Ws16 32766.00 Time_usec_q1_COMPU 1.000000 32767.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC O_T_RL50_Pwm.tiPh_C "" VALUE 0x802B970E Kw_Ws16 65535.00 OneToOne -32768.00 32767.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC PHLSNXMN "" VALUE 0x80284464 KwWU8 2.550 fak_q0p01 0.00 2.550 FORMAT "%5.3" /end CHARACTERISTIC
/begin CHARACTERISTIC PHLSNXSBB "" VALUE 0x80284465 KwWU8 2.550 fak_q0p01 0.00 2.550 FORMAT "%5.3" /end CHARACTERISTIC
/begin CHARACTERISTIC R2S2_xUsedDev_CW "" VALUE 0x802B9932 Val_Wu8 255.0 default 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Reset_rstFlMRErrBuf_C "" VALUE 0x802B9934 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Reset_rstHistBuf_C "" VALUE 0x802B9935 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Reset_rstTrapErrIntrBuf_C "" VALUE 0x802B9936 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Reset_xGrpId_C "" VALUE 0x802B9937 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Reset_xTrgId_C "" VALUE 0x802B9938 Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC RINNPH "" VALUE 0x802843F6 KwWU16 2559.961 r_q0p0391 0.00 2559.961 FORMAT "%8.3" /end CHARACTERISTIC
/begin CHARACTERISTIC RISIGRES "" VALUE 0x80284432 KwWU16 131070.0 r_uw_q2 0.00 131070.0 FORMAT "%8.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Rtmo_adCalling_u32 "" VALUE 0x802B993C Val_Wu32 4294967295.00 OneToOne 0.00 4294967295.00 FORMAT "%13.2" /end CHARACTERISTIC
/begin CHARACTERISTIC Rtmo_adData_u32 "" VALUE 0x802B9940 Val_Wu32 4294967295.00 OneToOne 0.00 4294967295.00 FORMAT "%13.2" /end CHARACTERISTIC
/begin CHARACTERISTIC Rtmo_stSampleTime_u8 "" VALUE 0x802B9944 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Rtmo_swLoadMode_u8 "" VALUE 0x802B9945 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Rtmo_swMode_u8 "" VALUE 0x802B9946 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Rtmo_tiIntOverhead_Tick "" VALUE 0x802B9948 Val_Wu32 4294967295.00 OneToOne 0.00 4294967295.00 FORMAT "%13.2" /end CHARACTERISTIC
/begin CHARACTERISTIC Rtmo_tiOverhead_Tick "" VALUE 0x802B994C Val_Wu32 4294967295.00 OneToOne 0.00 4294967295.00 FORMAT "%13.2" /end CHARACTERISTIC
/begin CHARACTERISTIC SBBF.CWDLSX "" VALUE 0x802844DC KwWU8 255.0 dez 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC SBBF.KLTTBMH "" CURVE 0x802844DE KlAxU8SstxU16WU16 6553.500 t_q0p1 0.00 6553.500 FORMAT "%8.3"
 /begin AXIS_DESCR STD_AXIS NO_INPUT_QUANTITY temp_q0p0234_om273 4 -273.1500 1262.827 FORMAT "%8.3" DEPOSIT ABSOLUTE /end AXIS_DESCR
/end CHARACTERISTIC
/begin CHARACTERISTIC SBBF.USREFKLT "" VALUE 0x802844F0 KwWU16 319.9951 spg_uw_q0p00488_o1 -1.000000 318.9951 FORMAT "%8.4" /end CHARACTERISTIC
/begin CHARACTERISTIC SBBF2.CWDLSX "" VALUE 0x802844F8 KwWU8 255.0 dez 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC SBBF2.KLTTBMH "" CURVE 0x802844FA KlAxU8SstxU16WU16 6553.500 t_q0p1 0.00 6553.500 FORMAT "%8.3"
 /begin AXIS_DESCR STD_AXIS NO_INPUT_QUANTITY temp_q0p0234_om273 4 -273.1500 1262.827 FORMAT "%8.3" DEPOSIT ABSOLUTE /end AXIS_DESCR
/end CHARACTERISTIC
/begin CHARACTERISTIC SBBF2.USREFKLT "" VALUE 0x8028450C KwWU16 319.9951 spg_uw_q0p00488_o1 -1.000000 318.9951 FORMAT "%8.4" /end CHARACTERISTIC
/begin CHARACTERISTIC SBBH.CWDLSX "" VALUE 0x80284514 KwWU8 255.0 dez 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC SBBH.KLTTBMH "" CURVE 0x80284516 KlAxU8SstxU16WU16 6553.500 t_q0p1 0.00 6553.500 FORMAT "%8.3"
 /begin AXIS_DESCR STD_AXIS NO_INPUT_QUANTITY temp_q0p0234_om273 4 -273.1500 1262.827 FORMAT "%8.3" DEPOSIT ABSOLUTE /end AXIS_DESCR
/end CHARACTERISTIC
/begin CHARACTERISTIC SBBH.USREFKLT "" VALUE 0x80284528 KwWU16 319.9951 spg_uw_q0p00488_o1 -1.000000 318.9951 FORMAT "%8.4" /end CHARACTERISTIC
/begin CHARACTERISTIC SBBH2.CWDLSX "" VALUE 0x80284530 KwWU8 255.0 dez 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC SBBH2.KLTTBMH "" CURVE 0x80284532 KlAxU8SstxU16WU16 6553.500 t_q0p1 0.00 6553.500 FORMAT "%8.3"
 /begin AXIS_DESCR STD_AXIS NO_INPUT_QUANTITY temp_q0p0234_om273 4 -273.1500 1262.827 FORMAT "%8.3" DEPOSIT ABSOLUTE /end AXIS_DESCR
/end CHARACTERISTIC
/begin CHARACTERISTIC SBBH2.USREFKLT "" VALUE 0x80284544 KwWU16 319.9951 spg_uw_q0p00488_o1 -1.000000 318.9951 FORMAT "%8.4" /end CHARACTERISTIC
/begin CHARACTERISTIC SBBZPV.CWDLSX "" VALUE 0x8028454C KwWU8 255.0 dez 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC SBBZPV2.CWDLSX "" VALUE 0x80284554 KwWU8 255.0 dez 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC Signals_Mode1Pid_CA "" VAL_BLK 0x802B9AF2 ValA_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" NUMBER 25 /end CHARACTERISTIC
/begin CHARACTERISTIC Signals_Mode1SigNum_CA "" VAL_BLK 0x802B9B0C ValA_Wu16 36.0000000000 Signals_IntSigNumVerb 0.00 36.0000000000 FORMAT "%13.10" NUMBER 25 /end CHARACTERISTIC
/begin CHARACTERISTIC SMLOXMH "" VALUE 0x80284448 KwWU16 2912.667 m_q0p0peri4 0.00 2912.667 FORMAT "%8.3" /end CHARACTERISTIC
/begin CHARACTERISTIC SULSUMN "" VALUE 0x802843F8 KwWU16 31.99951 spg_q4p88Em4 0.00 31.99951 FORMAT "%8.5" /end CHARACTERISTIC
/begin CHARACTERISTIC SULSUMX "Threshold value for plausibility fault CJ110" VALUE 0x8028506E KwWU16 31.99951 spg_q4p88Em4 0.00 31.99951 FORMAT "%8.5" /end CHARACTERISTIC
/begin CHARACTERISTIC SULSUMXL "Threshold value for plausibility fault CJ110, on low gain" VALUE 0x80285070 KwWU16 31.99951 spg_q4p88Em4 0.00 31.99951 FORMAT "%8.5" /end CHARACTERISTIC
/begin CHARACTERISTIC SwAdp_bCaSEdgAdapActv_C "" VALUE 0x80285072 KwWU8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC SyC_stTest_C "" VALUE 0x802B9B3E Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC SyC_swtTestEna_C "" VALUE 0x802B9B3F Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC SyC_tiPostDrvMax_C "" VALUE 0x802B9B40 Val_Wu16 3997.000 SyC_Time_100ms 3.000000 4000.000 FORMAT "%8.3" /end CHARACTERISTIC
/begin CHARACTERISTIC SyC_tiPostDrvMin_C "" VALUE 0x802B9B42 Val_Wu16 59.80000 SyC_Time_100ms 0.2000000 60.00000 FORMAT "%8.5" /end CHARACTERISTIC
/begin CHARACTERISTIC SyC_tiPostDrvResv_C "" VALUE 0x802B9B44 Val_Wu16 6553.500 SyC_Time_100ms 0.00 6553.500 FORMAT "%8.3" /end CHARACTERISTIC
/begin CHARACTERISTIC SyC_tiPreDrvMax_C "" VALUE 0x802B9B46 Val_Wu16 65534.00 Time_sec_q1_COMPU 1.000000 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC SyC_tiPreDrvResv_C "" VALUE 0x802B9B48 Val_Wu8 255.0 Time_sec_q1_COMPU 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC T15_Deb.tiHiLo_C "" VALUE 0x802B9B4A Kw_Ws16 655350.0 TimeDeb -327680.0 327670.0 FORMAT "%8.1" /end CHARACTERISTIC
/begin CHARACTERISTIC T15_Deb.tiLoHi_C "" VALUE 0x802B9B4C Kw_Ws16 655350.0 TimeDeb -327680.0 327670.0 FORMAT "%8.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TABGMHS "" VALUE 0x8028480A KwWU16 1535.977 temp_q0p0234_o273 -273.1500 1262.827 FORMAT "%8.3" /end CHARACTERISTIC
/begin CHARACTERISTIC TABGSZ "Time after start for LSU adjusting" VALUE 0x802846F6 KwWU16 6553.500 t_q0p1 0.00 6553.500 FORMAT "%8.3" /end CHARACTERISTIC
/begin CHARACTERISTIC TAHRLSUMX "max. duty cycle of actuation of LSU heater" VALUE 0x802843B4 KwWU16 199.9969 rel_uw_b200 0.00 199.9969 FORMAT "%8.4" /end CHARACTERISTIC
/begin CHARACTERISTIC TAHSVEMN "" VALUE 0x802843C6 KwWU16 199.9969 rel_uw_b200 0.00 199.9969 FORMAT "%8.4" /end CHARACTERISTIC
/begin CHARACTERISTIC TALSUSMX "" VALUE 0x802843FA KwWU16 1535.977 temp_q0p0234_o273 -273.1500 1262.827 FORMAT "%8.3" /end CHARACTERISTIC
/begin CHARACTERISTIC TAMDOG "" VALUE 0x80284466 KwWU16 1535.977 temp_q0p0234_om273 -273.1500 1262.827 FORMAT "%8.3" /end CHARACTERISTIC
/begin CHARACTERISTIC TAMDUG "" VALUE 0x80284468 KwWU16 1535.977 temp_q0p0234_om273 -273.1500 1262.827 FORMAT "%8.3" /end CHARACTERISTIC
/begin CHARACTERISTIC TAMSIG "" VALUE 0x80284434 KwWU16 1535.977 temp_q0p0234_om273 -273.1500 1262.827 FORMAT "%8.3" /end CHARACTERISTIC
/begin CHARACTERISTIC TASIG "" VALUE 0x8028445E KwWU8 25.50 t_q0p1 0.00 25.50 FORMAT "%5.2" /end CHARACTERISTIC
/begin CHARACTERISTIC TASIGV "" VALUE 0x8028444A KwWU8 25.50 t_q0p1 0.00 25.50 FORMAT "%5.2" /end CHARACTERISTIC
/begin CHARACTERISTIC TEHRLSUE "" VALUE 0x802843FC KwWU16 6553.500 t100msxs_uw_b6553p5 0.00 6553.500 FORMAT "%8.3" /end CHARACTERISTIC
/begin CHARACTERISTIC TENSBBLSU "temperature threshold for common electrical error LSU" VALUE 0x80284568 KwWU16 1535.977 temp_q0p0234_o273 -273.1500 1262.827 FORMAT "%8.3" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_BypDisableActivation_u8_C "" VALUE 0x802B9B50 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_BypInt_s16_C "" VALUE 0x802B9B52 Val_Ws16 65535.00 OneToOne -32768.00 32767.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_BypInt_s32_C "" VALUE 0x802B9B54 Val_Ws32 4294967295.00 OneToOne -2147483648.00 2147483647.00 FORMAT "%13.2" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_BypInt_s8_C "" VALUE 0x802B9B58 Val_Ws8 255.0 OneToOne -128.0 127.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_BypInt_u16_C "" VALUE 0x802B9B5A Val_Wu16 65535.00 OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_BypInt_u32_C "" VALUE 0x802B9B5C Val_Wu32 4294967295.00 OneToOne 0.00 4294967295.00 FORMAT "%13.2" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_BypInt_u8_C "" VALUE 0x802B9B60 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_CodeGen_T_Add_u8_Bypass.Vector "" VALUE 0x80282780 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_CodeGen_T_Add_u8_Bypass.Channel "" VALUE 0x80282781 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_CodeGen_T_Add_u8_Bypass.Offset "" VALUE 0x80282782 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_CodeGen_T_Rpl_u32_Bypass.Vector "" VALUE 0x80282784 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_CodeGen_T_Rpl_u32_Bypass.Channel "" VALUE 0x80282785 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_CodeGen_T_Rpl_u32_Bypass.Offset "" VALUE 0x80282786 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_s16_C "" VALUE 0x802B9B62 Val_Ws16 65535.00 OneToOne -32768.00 32767.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_s32_C "" VALUE 0x802B9B64 Val_Ws32 4294967295.00 OneToOne -2147483648.00 2147483647.00 FORMAT "%13.2" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_s8_C "" VALUE 0x802B9B68 Val_Ws8 255.0 OneToOne -128.0 127.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHookArray1_T_Rpl_u8_0_Bypass.Vector "" VALUE 0x80282788 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHookArray1_T_Rpl_u8_0_Bypass.Channel "" VALUE 0x80282789 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHookArray1_T_Rpl_u8_0_Bypass.Offset "" VALUE 0x8028278A Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHookArray1_T_Rpl_u8_1_Bypass.Vector "" VALUE 0x8028278C Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHookArray1_T_Rpl_u8_1_Bypass.Channel "" VALUE 0x8028278D Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHookArray1_T_Rpl_u8_1_Bypass.Offset "" VALUE 0x8028278E Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHookArray1_T_Rpl_u8_2_Bypass.Vector "" VALUE 0x80282790 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHookArray1_T_Rpl_u8_2_Bypass.Channel "" VALUE 0x80282791 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHookArray1_T_Rpl_u8_2_Bypass.Offset "" VALUE 0x80282792 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHookArray1_T_Rpl_u8_3_Bypass.Vector "" VALUE 0x80282794 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHookArray1_T_Rpl_u8_3_Bypass.Channel "" VALUE 0x80282795 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHookArray1_T_Rpl_u8_3_Bypass.Offset "" VALUE 0x80282796 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHookArray1_T_Rpl_u8_4_Bypass.Vector "" VALUE 0x80282798 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHookArray1_T_Rpl_u8_4_Bypass.Channel "" VALUE 0x80282799 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHookArray1_T_Rpl_u8_4_Bypass.Offset "" VALUE 0x8028279A Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHookArray2_T_Rpl_u8_0_Bypass.Vector "" VALUE 0x8028279C Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHookArray2_T_Rpl_u8_0_Bypass.Channel "" VALUE 0x8028279D Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHookArray2_T_Rpl_u8_0_Bypass.Offset "" VALUE 0x8028279E Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHookArray2_T_Rpl_u8_1_Bypass.Vector "" VALUE 0x802827A0 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHookArray2_T_Rpl_u8_1_Bypass.Channel "" VALUE 0x802827A1 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHookArray2_T_Rpl_u8_1_Bypass.Offset "" VALUE 0x802827A2 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHookArray2_T_Rpl_u8_2_Bypass.Vector "" VALUE 0x802827A4 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHookArray2_T_Rpl_u8_2_Bypass.Channel "" VALUE 0x802827A5 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHookArray2_T_Rpl_u8_2_Bypass.Offset "" VALUE 0x802827A6 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHookArray2_T_Rpl_u8_3_Bypass.Vector "" VALUE 0x802827A8 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHookArray2_T_Rpl_u8_3_Bypass.Channel "" VALUE 0x802827A9 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHookArray2_T_Rpl_u8_3_Bypass.Offset "" VALUE 0x802827AA Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHookArray2_T_Rpl_u8_4_Bypass.Vector "" VALUE 0x802827AC Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHookArray2_T_Rpl_u8_4_Bypass.Channel "" VALUE 0x802827AD Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHookArray2_T_Rpl_u8_4_Bypass.Offset "" VALUE 0x802827AE Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHookArray3_T_Add_u8_0Add_Bypass.Vector "" VALUE 0x802827B0 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHookArray3_T_Add_u8_0Add_Bypass.Channel "" VALUE 0x802827B1 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHookArray3_T_Add_u8_0Add_Bypass.Offset "" VALUE 0x802827B2 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHookArray3_T_Add_u8_1Add_Bypass.Vector "" VALUE 0x802827B4 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHookArray3_T_Add_u8_1Add_Bypass.Channel "" VALUE 0x802827B5 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHookArray3_T_Add_u8_1Add_Bypass.Offset "" VALUE 0x802827B6 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHookArray3_T_Add_u8_2Add_Bypass.Vector "" VALUE 0x802827B8 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHookArray3_T_Add_u8_2Add_Bypass.Channel "" VALUE 0x802827B9 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHookArray3_T_Add_u8_2Add_Bypass.Offset "" VALUE 0x802827BA Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHookArray3_T_Add_u8_3Add_Bypass.Vector "" VALUE 0x802827BC Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHookArray3_T_Add_u8_3Add_Bypass.Channel "" VALUE 0x802827BD Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHookArray3_T_Add_u8_3Add_Bypass.Offset "" VALUE 0x802827BE Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHookArray3_T_Add_u8_4Add_Bypass.Vector "" VALUE 0x802827C0 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHookArray3_T_Add_u8_4Add_Bypass.Channel "" VALUE 0x802827C1 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHookArray3_T_Add_u8_4Add_Bypass.Offset "" VALUE 0x802827C2 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHook_N_Add_r32Add_Bypass.Vector "" VALUE 0x802827C4 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHook_N_Add_r32Add_Bypass.Channel "" VALUE 0x802827C5 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHook_N_Add_r32Add_Bypass.Offset "" VALUE 0x802827C6 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHook_N_Add_s16Add_Bypass.Vector "" VALUE 0x802827C8 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHook_N_Add_s16Add_Bypass.Channel "" VALUE 0x802827C9 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHook_N_Add_s16Add_Bypass.Offset "" VALUE 0x802827CA Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHook_N_Add_s32Add_Bypass.Vector "" VALUE 0x802827CC Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHook_N_Add_s32Add_Bypass.Channel "" VALUE 0x802827CD Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHook_N_Add_s32Add_Bypass.Offset "" VALUE 0x802827CE Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHook_N_Add_s8Add2_Bypass.Vector "" VALUE 0x802827D0 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHook_N_Add_s8Add2_Bypass.Channel "" VALUE 0x802827D1 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHook_N_Add_s8Add2_Bypass.Offset "" VALUE 0x802827D2 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHook_N_Add_u16Add_Bypass.Vector "" VALUE 0x802827D4 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHook_N_Add_u16Add_Bypass.Channel "" VALUE 0x802827D5 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHook_N_Add_u16Add_Bypass.Offset "" VALUE 0x802827D6 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHook_N_Add_u32Add_Bypass.Vector "" VALUE 0x802827D8 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHook_N_Add_u32Add_Bypass.Channel "" VALUE 0x802827D9 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHook_N_Add_u32Add_Bypass.Offset "" VALUE 0x802827DA Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHook_N_Add_u8Add_Bypass.Vector "" VALUE 0x802827DC Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHook_N_Add_u8Add_Bypass.Channel "" VALUE 0x802827DD Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHook_N_Add_u8Add_Bypass.Offset "" VALUE 0x802827DE Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHook_N_Rpl_r32_Bypass.Vector "" VALUE 0x802827E0 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHook_N_Rpl_r32_Bypass.Channel "" VALUE 0x802827E1 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHook_N_Rpl_r32_Bypass.Offset "" VALUE 0x802827E2 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHook_N_Rpl_s16_Bypass.Vector "" VALUE 0x802827E4 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHook_N_Rpl_s16_Bypass.Channel "" VALUE 0x802827E5 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHook_N_Rpl_s16_Bypass.Offset "" VALUE 0x802827E6 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHook_N_Rpl_s32_Bypass.Vector "" VALUE 0x802827E8 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHook_N_Rpl_s32_Bypass.Channel "" VALUE 0x802827E9 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHook_N_Rpl_s32_Bypass.Offset "" VALUE 0x802827EA Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHook_N_Rpl_s8_Bypass.Vector "" VALUE 0x802827EC Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHook_N_Rpl_s8_Bypass.Channel "" VALUE 0x802827ED Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHook_N_Rpl_s8_Bypass.Offset "" VALUE 0x802827EE Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHook_N_Rpl_u16Add_Bypass.Vector "" VALUE 0x802827F0 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHook_N_Rpl_u16Add_Bypass.Channel "" VALUE 0x802827F1 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHook_N_Rpl_u16Add_Bypass.Offset "" VALUE 0x802827F2 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHook_N_Rpl_u32_Bypass.Vector "" VALUE 0x802827F4 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHook_N_Rpl_u32_Bypass.Channel "" VALUE 0x802827F5 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHook_N_Rpl_u32_Bypass.Offset "" VALUE 0x802827F6 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHook_N_Rpl_u8_Bypass.Vector "" VALUE 0x802827F8 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHook_N_Rpl_u8_Bypass.Channel "" VALUE 0x802827F9 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHook_N_Rpl_u8_Bypass.Offset "" VALUE 0x802827FA Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHook_T_Add_r32Add_Bypass.Vector "" VALUE 0x802827FC Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHook_T_Add_r32Add_Bypass.Channel "" VALUE 0x802827FD Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHook_T_Add_r32Add_Bypass.Offset "" VALUE 0x802827FE Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHook_T_Add_s16Add_Bypass.Vector "" VALUE 0x80282800 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHook_T_Add_s16Add_Bypass.Channel "" VALUE 0x80282801 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHook_T_Add_s16Add_Bypass.Offset "" VALUE 0x80282802 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHook_T_Add_s32_Bypass.Vector "" VALUE 0x80282804 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHook_T_Add_s32_Bypass.Channel "" VALUE 0x80282805 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHook_T_Add_s32_Bypass.Offset "" VALUE 0x80282806 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHook_T_Add_s8Add_Bypass.Vector "" VALUE 0x80282808 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHook_T_Add_s8Add_Bypass.Channel "" VALUE 0x80282809 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHook_T_Add_s8Add_Bypass.Offset "" VALUE 0x8028280A Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHook_T_Add_u16Add_Bypass.Vector "" VALUE 0x8028280C Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHook_T_Add_u16Add_Bypass.Channel "" VALUE 0x8028280D Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHook_T_Add_u16Add_Bypass.Offset "" VALUE 0x8028280E Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHook_T_Add_u32Add_Bypass.Vector "" VALUE 0x80282810 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHook_T_Add_u32Add_Bypass.Channel "" VALUE 0x80282811 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHook_T_Add_u32Add_Bypass.Offset "" VALUE 0x80282812 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHook_T_Add_u8Add_Bypass.Vector "" VALUE 0x80282814 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHook_T_Add_u8Add_Bypass.Channel "" VALUE 0x80282815 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHook_T_Add_u8Add_Bypass.Offset "" VALUE 0x80282816 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHook_T_Read_Bit_1_Bypass.Vector "" VALUE 0x80282818 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHook_T_Read_Bit_1_Bypass.Channel "" VALUE 0x80282819 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHook_T_Read_Bit_1_Bypass.Offset "" VALUE 0x8028281A Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHook_T_Read_Bit_2_Bypass.Vector "" VALUE 0x8028281C Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHook_T_Read_Bit_2_Bypass.Channel "" VALUE 0x8028281D Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHook_T_Read_Bit_2_Bypass.Offset "" VALUE 0x8028281E Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHook_T_Rpl_r32_Bypass.Vector "" VALUE 0x80282820 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHook_T_Rpl_r32_Bypass.Channel "" VALUE 0x80282821 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHook_T_Rpl_r32_Bypass.Offset "" VALUE 0x80282822 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHook_T_Rpl_s16_Bypass.Vector "" VALUE 0x80282824 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHook_T_Rpl_s16_Bypass.Channel "" VALUE 0x80282825 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHook_T_Rpl_s16_Bypass.Offset "" VALUE 0x80282826 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHook_T_Rpl_s32_Bypass.Vector "" VALUE 0x80282828 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHook_T_Rpl_s32_Bypass.Channel "" VALUE 0x80282829 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHook_T_Rpl_s32_Bypass.Offset "" VALUE 0x8028282A Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHook_T_Rpl_s8_Bypass.Vector "" VALUE 0x8028282C Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHook_T_Rpl_s8_Bypass.Channel "" VALUE 0x8028282D Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHook_T_Rpl_s8_Bypass.Offset "" VALUE 0x8028282E Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHook_T_Rpl_u16_Bypass.Vector "" VALUE 0x80282830 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHook_T_Rpl_u16_Bypass.Channel "" VALUE 0x80282831 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin CHARACTERISTIC TestCD_Byp_TestHook_T_Rpl_u16_Bypass.Offset "" VALUE 0x80282832 Val_Wu8 255.0 OneToOne 0.00 255.0 FORMAT "%5.1" /end CHARACTERISTIC
/begin COMPU_METHOD AngleCrS "" RAT_FUNC "%6.4" "deg CrS" COEFFS 0 45.5111111111 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD dez "" RAT_FUNC "%6.2" "" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD DFC_OneToOne "" RAT_FUNC "%6.2" "-" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD DFC_Verb "" TAB_VERB "%2.1" "-" COMPU_TAB_REF DFC_Verb /end COMPU_METHOD
/begin COMPU_VTAB DFC_Verb "" TAB_VERB 425 0 "DFC_Unused" 1 "DFC_BusDiagBusOffErrPasNodeA" 2 "DFC_BusDiagBusOffErrPasNodeB" 3 "DFC_BusDiagBusOffErrPasNodeC" 4 "DFC_BusDiagBusOffErrPasNodeD" 5 "DFC_BusDiagBusOffNodeA" 6 "DFC_BusDiagBusOffNodeB" 7 "DFC_BusDiagBusOffNodeC" 8 "DFC_BusDiagBusOffNodeD" 9 "DFC_ComCANG1_HDL0TO" 10 "DFC_ComCANG1_HDL10TO" 11 "DFC_ComCANG1_HDL11TO" 12 "DFC_ComCANG1_HDL12TO" 13 "DFC_ComCANG1_HDL13TO" 14 "DFC_ComCANG1_HDL14TO" 15 "DFC_ComCANG1_HDL15TO" 16 "DFC_ComCANG1_HDL16TO" 17 "DFC_ComCANG1_HDL17TO" 18 "DFC_ComCANG1_HDL18TO" 19 "DFC_ComCANG1_HDL19TO" 20 "DFC_ComCANG1_HDL1TO" 21 "DFC_ComCANG1_HDL20TO" 22 "DFC_ComCANG1_HDL21TO" 23 "DFC_ComCANG1_HDL22TO" 24 "DFC_ComCANG1_HDL23TO" 25 "DFC_ComCANG1_HDL24TO" 26 "DFC_ComCANG1_HDL2TO" 27 "DFC_ComCANG1_HDL3TO" 28 "DFC_ComCANG1_HDL4TO" 29 "DFC_ComCANG1_HDL5TO" 30 "DFC_ComCANG1_HDL6TO" 31 "DFC_ComCANG1_HDL7TO" 32 "DFC_ComCANG1_HDL8TO" 33 "DFC_ComCANG1_HDL9TO" 34 "DFC_ComCANG2_HDL0TO" 35 "DFC_ComCANG2_HDL10TO" 36 "DFC_ComCANG2_HDL11TO" 37 "DFC_ComCANG2_HDL12TO" 38 "DFC_ComCANG2_HDL13TO" 39 "DFC_ComCANG2_HDL14TO" 40 "DFC_ComCANG2_HDL15TO" 41 "DFC_ComCANG2_HDL16TO" 42 "DFC_ComCANG2_HDL17TO" 43 "DFC_ComCANG2_HDL18TO" 44 "DFC_ComCANG2_HDL19TO" 45 "DFC_ComCANG2_HDL1TO" 46 "DFC_ComCANG2_HDL20TO" 47 "DFC_ComCANG2_HDL21TO" 48 "DFC_ComCANG2_HDL22TO" 49 "DFC_ComCANG2_HDL23TO" 50 "DFC_ComCANG2_HDL24TO" 51 "DFC_ComCANG2_HDL2TO" 52 "DFC_ComCANG2_HDL3TO" 53 "DFC_ComCANG2_HDL4TO" 54 "DFC_ComCANG2_HDL5TO" 55 "DFC_ComCANG2_HDL6TO" 56 "DFC_ComCANG2_HDL7TO" 57 "DFC_ComCANG2_HDL8TO" 58 "DFC_ComCANG2_HDL9TO" 59 "DFC_ComCANG3_HDL0TO" 60 "DFC_ComCANG3_HDL10TO" 61 "DFC_ComCANG3_HDL11TO" 62 "DFC_ComCANG3_HDL12TO" 63 "DFC_ComCANG3_HDL13TO" 64 "DFC_ComCANG3_HDL14TO" 65 "DFC_ComCANG3_HDL15TO" 66 "DFC_ComCANG3_HDL16TO" 67 "DFC_ComCANG3_HDL17TO" 68 "DFC_ComCANG3_HDL18TO" 69 "DFC_ComCANG3_HDL19TO" 70 "DFC_ComCANG3_HDL1TO" 71 "DFC_ComCANG3_HDL20TO" 72 "DFC_ComCANG3_HDL21TO" 73 "DFC_ComCANG3_HDL22TO" 74 "DFC_ComCANG3_HDL23TO" 75 "DFC_ComCANG3_HDL24TO" 76 "DFC_ComCANG3_HDL2TO" 77 "DFC_ComCANG3_HDL3TO" 78 "DFC_ComCANG3_HDL4TO" 79 "DFC_ComCANG3_HDL5TO" 80 "DFC_ComCANG3_HDL6TO" 81 "DFC_ComCANG3_HDL7TO" 82 "DFC_ComCANG3_HDL8TO" 83 "DFC_ComCANG3_HDL9TO" 84 "DFC_ComCANG4_HDL0TO" 85 "DFC_ComCANG4_HDL10TO" 86 "DFC_ComCANG4_HDL11TO" 87 "DFC_ComCANG4_HDL12TO" 88 "DFC_ComCANG4_HDL13TO" 89 "DFC_ComCANG4_HDL14TO" 90 "DFC_ComCANG4_HDL15TO" 91 "DFC_ComCANG4_HDL16TO" 92 "DFC_ComCANG4_HDL17TO" 93 "DFC_ComCANG4_HDL18TO" 94 "DFC_ComCANG4_HDL19TO" 95 "DFC_ComCANG4_HDL1TO" 96 "DFC_ComCANG4_HDL20TO" 97 "DFC_ComCANG4_HDL21TO" 98 "DFC_ComCANG4_HDL22TO" 99 "DFC_ComCANG4_HDL23TO" 100 "DFC_ComCANG4_HDL24TO" 101 "DFC_ComCANG4_HDL2TO" 102 "DFC_ComCANG4_HDL3TO" 103 "DFC_ComCANG4_HDL4TO" 104 "DFC_ComCANG4_HDL5TO" 105 "DFC_ComCANG4_HDL6TO" 106 "DFC_ComCANG4_HDL7TO" 107 "DFC_ComCANG4_HDL8TO" 108 "DFC_ComCANG4_HDL9TO" 109 "DFC_Cy150SpiCom" 110 "DFC_Cy320SpiCom" 212 "DFC_DevLibBattUHi" 213 "DFC_DevLibBattULo" 214 "DFC_DSMDummy" 215 "DFC_EEPEraseErr" 216 "DFC_EEPRdErr" 217 "DFC_EEPWrErr" 242 "DFC_EpmCaSI1ErrSig" 243 "DFC_EpmCaSI1NoSigMax" 244 "DFC_EpmCaSI1NoSigMin" 245 "DFC_EpmCaSI1OfsErr" 246 "DFC_EpmCaSI2ErrSig" 247 "DFC_EpmCaSI2NoSigMax" 248 "DFC_EpmCaSI2NoSigMin" 249 "DFC_EpmCaSI2OfsErr" 250 "DFC_EpmCaSO1ErrSig" 251 "DFC_EpmCaSO1NoSigMax" 252 "DFC_EpmCaSO1NoSigMin" 253 "DFC_EpmCaSO1OfsErr" 254 "DFC_EpmCaSO2ErrSig" 255 "DFC_EpmCaSO2NoSigMax" 256 "DFC_EpmCaSO2NoSigMin" 257 "DFC_EpmCaSO2OfsErr" 258 "DFC_EpmCrSDGI" 259 "DFC_EpmCrSErrSig" 260 "DFC_EpmCrSNoSig" 218 "DFC_EV1max" 219 "DFC_EV1min" 220 "DFC_EV1sig" 221 "DFC_EV2max" 222 "DFC_EV2min" 223 "DFC_EV2sig" 224 "DFC_EV3max" 225 "DFC_EV3min" 226 "DFC_EV3sig" 227 "DFC_EV4max" 228 "DFC_EV4min" 229 "DFC_EV4sig" 230 "DFC_EV5max" 231 "DFC_EV5min" 232 "DFC_EV5sig" 233 "DFC_EV6max" 234 "DFC_EV6min" 235 "DFC_EV6sig" 236 "DFC_EV7max" 237 "DFC_EV7min" 238 "DFC_EV7sig" 239 "DFC_EV8max" 240 "DFC_EV8min" 241 "DFC_EV8sig" 261 "DFC_HDEVH_MAX_0" 262 "DFC_HDEVH_MAX_1" 263 "DFC_HDEVH_MAX_2" 264 "DFC_HDEVH_MAX_3" 265 "DFC_HDEVH_MAX_4" 266 "DFC_HDEVH_MAX_5" 267 "DFC_HDEVH_MAX_6" 268 "DFC_HDEVH_MAX_7" 269 "DFC_HDEVH_MIN_0" 270 "DFC_HDEVH_MIN_1" 271 "DFC_HDEVH_MIN_2" 272 "DFC_HDEVH_MIN_3" 273 "DFC_HDEVH_MIN_4" 274 "DFC_HDEVH_MIN_5" 275 "DFC_HDEVH_MIN_6" 276 "DFC_HDEVH_MIN_7" 277 "DFC_HDEVH_NPL_0" 278 "DFC_HDEVH_NPL_1" 279 "DFC_HDEVH_NPL_2" 280 "DFC_HDEVH_NPL_3" 281 "DFC_HDEVH_NPL_4" 282 "DFC_HDEVH_NPL_5" 283 "DFC_HDEVH_NPL_6" 284 "DFC_HDEVH_NPL_7" 126 "DFC_HDEVK_MIN_0" 127 "DFC_HDEVK_MIN_1" 128 "DFC_HDEVK_NPL_0" 129 "DFC_HDEVK_NPL_1" 130 "DFC_HDEVK_SIG_0" 131 "DFC_HDEVK_SIG_1" 285 "DFC_HDEVL_MAX_0" 286 "DFC_HDEVL_MAX_1" 287 "DFC_HDEVL_MAX_2" 288 "DFC_HDEVL_MAX_3" 289 "DFC_HDEVL_MAX_4" 290 "DFC_HDEVL_MAX_5" 291 "DFC_HDEVL_MAX_6" 292 "DFC_HDEVL_MAX_7" 293 "DFC_HDEVL_MIN_0" 294 "DFC_HDEVL_MIN_1" 295 "DFC_HDEVL_MIN_2" 296 "DFC_HDEVL_MIN_3" 297 "DFC_HDEVL_MIN_4" 298 "DFC_HDEVL_MIN_5" 299 "DFC_HDEVL_MIN_6" 300 "DFC_HDEVL_MIN_7" 301 "DFC_HDEVL_NPL_0" 302 "DFC_HDEVL_NPL_1" 303 "DFC_HDEVL_NPL_2" 304 "DFC_HDEVL_NPL_3" 305 "DFC_HDEVL_NPL_4" 306 "DFC_HDEVL_NPL_5" 307 "DFC_HDEVL_NPL_6" 308 "DFC_HDEVL_NPL_7" 309 "DFC_HDEVL_SIG_0" 310 "DFC_HDEVL_SIG_1" 311 "DFC_HDEVL_SIG_2" 312 "DFC_HDEVL_SIG_3" 313 "DFC_HDEVL_SIG_4" 314 "DFC_HDEVL_SIG_5" 315 "DFC_HDEVL_SIG_6" 316 "DFC_HDEVL_SIG_7" 317 "DFC_HSFE2max" 318 "DFC_HSFE2min" 319 "DFC_HSFE2sig" 320 "DFC_HSFEmax" 321 "DFC_HSFEmin" 322 "DFC_HSFEsig" 323 "DFC_HSHE2max" 324 "DFC_HSHE2min" 325 "DFC_HSHE2sig" 326 "DFC_HSHEmax" 327 "DFC_HSHEmin" 328 "DFC_HSHEsig" 329 "DFC_HSVE2max" 330 "DFC_HSVE2maxLSF" 331 "DFC_HSVE2min" 332 "DFC_HSVE2minLSF" 333 "DFC_HSVE2sig" 334 "DFC_HSVE2sigLSF" 335 "DFC_HSVEmax" 336 "DFC_HSVEmaxLSF" 337 "DFC_HSVEmin" 338 "DFC_HSVEminLSF" 339 "DFC_HSVEsig" 340 "DFC_HSVEsigLSF" 341 "DFC_ICLSU2max" 342 "DFC_ICLSU2min" 343 "DFC_ICLSU2npl" 344 "DFC_ICLSU2sig" 345 "DFC_ICLSUmax" 346 "DFC_ICLSUmin" 347 "DFC_ICLSUnpl" 348 "DFC_ICLSUsig" 132 "DFC_IgnClPsClOpen0" 133 "DFC_IgnClPsClOpen1" 134 "DFC_IgnClPsClOpen2" 135 "DFC_IgnClPsClOpen3" 136 "DFC_IgnClPsClOpen4" 137 "DFC_IgnClPsClOpen5" 138 "DFC_IgnClPsClOpen6" 139 "DFC_IgnClPsClOpen7" 140 "DFC_IgnClPsClShCir0" 141 "DFC_IgnClPsClShCir1" 142 "DFC_IgnClPsClShCir2" 143 "DFC_IgnClPsClShCir3" 144 "DFC_IgnClPsClShCir4" 145 "DFC_IgnClPsClShCir5" 146 "DFC_IgnClPsClShCir6" 147 "DFC_IgnClPsClShCir7" 148 "DFC_IgnClPsClUnExpt0" 149 "DFC_IgnClPsClUnExpt1" 150 "DFC_IgnClPsClUnExpt2" 151 "DFC_IgnClPsClUnExpt3" 152 "DFC_IgnClPsClUnExpt4" 153 "DFC_IgnClPsClUnExpt5" 154 "DFC_IgnClPsClUnExpt6" 155 "DFC_IgnClPsClUnExpt7" 156 "DFC_IgnClPsDevIdentErr1" 157 "DFC_IgnClPsDevIdentErr2" 158 "DFC_IgnClPsDevInitErr1" 159 "DFC_IgnClPsDevInitErr2" 160 "DFC_IgnClPsDevOscErr1" 161 "DFC_IgnClPsDevOscErr2" 162 "DFC_IgnClPsDevSpiErr1" 163 "DFC_IgnClPsDevSpiErr2" 164 "DFC_IgnClPsOpenLoad0" 165 "DFC_IgnClPsOpenLoad1" 166 "DFC_IgnClPsOpenLoad2" 167 "DFC_IgnClPsOpenLoad3" 168 "DFC_IgnClPsOpenLoad4" 169 "DFC_IgnClPsOpenLoad5" 170 "DFC_IgnClPsOpenLoad6" 171 "DFC_IgnClPsOpenLoad7" 172 "DFC_IgnClPsShCirBatt0" 173 "DFC_IgnClPsShCirBatt1" 174 "DFC_IgnClPsShCirBatt2" 175 "DFC_IgnClPsShCirBatt3" 176 "DFC_IgnClPsShCirBatt4" 177 "DFC_IgnClPsShCirBatt5" 178 "DFC_IgnClPsShCirBatt6" 179 "DFC_IgnClPsShCirBatt7" 180 "DFC_IgnClPsShCirGnd0" 181 "DFC_IgnClPsShCirGnd1" 182 "DFC_IgnClPsShCirGnd2" 183 "DFC_IgnClPsShCirGnd3" 184 "DFC_IgnClPsShCirGnd4" 185 "DFC_IgnClPsShCirGnd5" 186 "DFC_IgnClPsShCirGnd6" 187 "DFC_IgnClPsShCirGnd7" 188 "DFC_KnDetSens1PortAMax" 189 "DFC_KnDetSens1PortAMin" 190 "DFC_KnDetSens1PortBMax" 191 "DFC_KnDetSens1PortBMin" 192 "DFC_KnDetSens2PortAMax" 193 "DFC_KnDetSens2PortAMin" 194 "DFC_KnDetSens2PortBMax" 195 "DFC_KnDetSens2PortBMin" 196 "DFC_KnDetSens3PortAMax" 197 "DFC_KnDetSens3PortAMin" 198 "DFC_KnDetSens3PortBMax" 199 "DFC_KnDetSens3PortBMin" 200 "DFC_KnDetSens4PortAMax" 201 "DFC_KnDetSens4PortAMin" 202 "DFC_KnDetSens4PortBMax" 203 "DFC_KnDetSens4PortBMin" 349 "DFC_LSF2max" 350 "DFC_LSF2min" 351 "DFC_LSF2npl" 352 "DFC_LSF2sig" 353 "DFC_LSFmax" 354 "DFC_LSFmin" 355 "DFC_LSFnpl" 356 "DFC_LSFsig" 357 "DFC_LSH2max" 358 "DFC_LSH2min" 359 "DFC_LSH2npl" 360 "DFC_LSH2sig" 361 "DFC_LSHmax" 362 "DFC_LSHmin" 363 "DFC_LSHnpl" 364 "DFC_LSHsig" 365 "DFC_LSUIA2sig" 366 "DFC_LSUIAsig" 367 "DFC_LSUIP2max" 368 "DFC_LSUIP2npl" 369 "DFC_LSUIP2sig" 370 "DFC_LSUIPmax" 371 "DFC_LSUIPnpl" 372 "DFC_LSUIPsig" 373 "DFC_LSUKS2max" 374 "DFC_LSUKS2min" 375 "DFC_LSUKSmax" 376 "DFC_LSUKSmin" 377 "DFC_LSUUN2sig" 378 "DFC_LSUUNsig" 379 "DFC_LSUVM2sig" 380 "DFC_LSUVMsig" 381 "DFC_LSV2max" 382 "DFC_LSV2min" 383 "DFC_LSV2npl" 384 "DFC_LSV2sig" 385 "DFC_LSVmax" 386 "DFC_LSVmin" 387 "DFC_LSVnpl" 388 "DFC_LSVsig" 389 "DFC_MD00max" 390 "DFC_MD00min" 391 "DFC_MD00npl" 392 "DFC_MD01max" 393 "DFC_MD01min" 394 "DFC_MD01npl" 395 "DFC_MD02max" 396 "DFC_MD02min" 397 "DFC_MD02npl" 398 "DFC_MD03max" 399 "DFC_MD03min" 400 "DFC_MD03npl" 401 "DFC_MD04max" 402 "DFC_MD04min" 403 "DFC_MD04npl" 404 "DFC_MD05max" 405 "DFC_MD05min" 406 "DFC_MD05npl" 407 "DFC_MD06max" 408 "DFC_MD06min" 409 "DFC_MD06npl" 410 "DFC_MD07max" 411 "DFC_MD07min" 412 "DFC_MD07npl" 413 "DFC_MDmax" 414 "DFC_MDmin" 415 "DFC_MDnpl" 204 "DFC_MfPsNonPlausible" 205 "DFC_MfPsNonPlausible2" 206 "DFC_MfPsOpenLoad" 207 "DFC_MfPsOpenLoad2" 208 "DFC_MfPsShCirBattLowSide" 209 "DFC_MfPsShCirBattLowSide2" 210 "DFC_MfPsShCirGndLowSide" 211 "DFC_MfPsShCirGndLowSide2" 111 "DFC_MonUMaxSupply1" 112 "DFC_MonUMaxSupply2" 113 "DFC_MonUMaxSupply3" 114 "DFC_MonUMinSupply1" 115 "DFC_MonUMinSupply2" 116 "DFC_MonUMinSupply3" 416 "DFC_MRlyErlyOpng" 417 "DFC_MRlyStk" 418 "DFC_PLLSUmax" 419 "DFC_PLLSUmin" 420 "DFC_PLLSUnpl" 421 "DFC_PLLSUsig" 117 "DFC_SSpMon1" 118 "DFC_SSpMon1OV" 119 "DFC_SSpMon1UV" 120 "DFC_SSpMon2" 121 "DFC_SSpMon2OV" 122 "DFC_SSpMon2UV" 123 "DFC_SSpMon3" 124 "DFC_SSpMon3OV" 125 "DFC_SSpMon3UV" 422 "DFC_SWReset_0" 423 "DFC_SWReset_1" 424 "DFC_SWReset_2" DEFAULT_VALUE "---" /end COMPU_VTAB
/begin COMPU_METHOD DFES_OneToOne "" RAT_FUNC "%6.2" "-" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD DINH_OneToOne "" RAT_FUNC "%6.2" "-" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD DSCHED_FIdVerb "" TAB_VERB "%2.1" "-" COMPU_TAB_REF DSCHED_FIdVerb /end COMPU_METHOD
/begin COMPU_VTAB DSCHED_FIdVerb "" TAB_VERB 3 0 "FId_Unused" 1 "FId_InhibitAlways" 2 "FId_CoordTDCAdap" DEFAULT_VALUE "---" /end COMPU_VTAB
/begin COMPU_METHOD DSCHED_RmpSlp "" RAT_FUNC "%6.2" "counts/s" COEFFS 0 1 0 0 0 5 /end COMPU_METHOD
/begin COMPU_METHOD DSCHED_Time200ms "" RAT_FUNC "%6.3" "s" COEFFS 0 5 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD DSMDur_EvntSel_Verb "" TAB_VERB "%6.3" "-" COMPU_TAB_REF DSMDur_EvntSel_Verb /end COMPU_METHOD
/begin COMPU_VTAB DSMDur_EvntSel_Verb "" TAB_VERB 5 0 "NoCountEvent" 1 "DistanceEvents" 2 "TimeEvents" 4 "WarmUpCycleEvents" 8 "DistanceEvents10m" /end COMPU_VTAB
/begin COMPU_METHOD DSMRdy_OneToOne "" RAT_FUNC "%6.2" "-" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD DTR_Fact "" RAT_FUNC "%6.5" "-" COEFFS 0 8192 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD DTR_Verb "" TAB_VERB "%2.1" "-" COMPU_TAB_REF DTR_Verb /end COMPU_METHOD
/begin COMPU_VTAB DTR_Verb "" TAB_VERB 7 0 "DTR_Dummy" 1 "DTR_OBDMID_01_TID_OCIA" 2 "DTR_OBDMID_01_TID_OCIP" 3 "DTR_OBDMID_05_TID_OCIA" 4 "DTR_OBDMID_05_TID_OCIP" 5 "DTR_dummy" 255 "DTR_Unused" DEFAULT_VALUE "FALSE" /end COMPU_VTAB
/begin COMPU_METHOD EngN "" RAT_FUNC "%6.3" "rpm" COEFFS 0 2 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD EngNGrd "" RAT_FUNC "%6.3" "rpm/s" COEFFS 0 2 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD EpmBCa_FacTstInj "" RAT_FUNC "%6.5" "-" COEFFS 0 1000 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD EPM_FAC_PLAUS "" RAT_FUNC "%6.4" "-" COEFFS 0 16 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD ESC_stS1FrstSched_t "" TAB_VERB "%6.3" "" COMPU_TAB_REF ESC_stS1FrstSched_t /end COMPU_METHOD
/begin COMPU_VTAB ESC_stS1FrstSched_t "" TAB_VERB 4 0 "ESC_SX_SCHEDSTRT" 1 "ESC_S1_SCHEDSTRT" 2 "ESC_S0_SCHEDSTRT" 3 "ESC_S1FORCED_SCHEDSTRT" /end COMPU_VTAB
/begin COMPU_METHOD fak_q0p01 "" RAT_FUNC "%6.4" "" COEFFS 0 100 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD fak_uw_b16 "" RAT_FUNC "%6.5" "-" COEFFS 0 65536 0 0 0 16 /end COMPU_METHOD
/begin COMPU_METHOD fak_uw_b2 "" RAT_FUNC "%7.6" "-" COEFFS 0 65536 0 0 0 2 /end COMPU_METHOD
/begin COMPU_METHOD fak_uw_b4 "" RAT_FUNC "%7.6" "-" COEFFS 0 65536 0 0 0 4 /end COMPU_METHOD
/begin COMPU_METHOD I15031_PID1CVerb "" TAB_VERB "%6.3" "-" COMPU_TAB_REF I15031_PID1CVerb /end COMPU_METHOD
/begin COMPU_VTAB I15031_PID1CVerb "" TAB_VERB 21 1 "OBD II" 2 "OBD" 3 "OBD and OBD II" 4 "OBD I" 5 "No OBD" 6 "EOBD" 7 "EOBD and OBD II" 8 "EOBD and OBD" 9 "EOBD, OBD and OBD II" 10 "JOBD" 11 "JOBD and OBD II" 12 "JOBD and EOBD" 13 "JOBD, EOBD and OBD II" 17 "EMD" 18 "EMD+" 19 "HD OBD-C" 20 "HD OBD" 21 "WWH OBD" 23 "HD EOBD" 28 "OBDBr-1" 29 "OBDBr-2" /end COMPU_VTAB
/begin COMPU_METHOD I15031_PID5FVerb "" TAB_VERB "%6.3" "-" COMPU_TAB_REF I15031_PID5FVerb /end COMPU_METHOD
/begin COMPU_VTAB I15031_PID5FVerb "" TAB_VERB 3 14 "EURO IV B1" 15 "EURO V B2" 16 "EURO C" /end COMPU_VTAB
/begin COMPU_METHOD injdd_InjTypeFuelMode_State_t "" TAB_VERB "%6.3" "" COMPU_TAB_REF injdd_InjTypeFuelMode_State_t /end COMPU_METHOD
/begin COMPU_VTAB injdd_InjTypeFuelMode_State_t "" TAB_VERB 2 0 "INJ_TYPE_GDI" 1 "INJ_TYPE_GPFI" /end COMPU_VTAB
/begin COMPU_METHOD ispg_q0p25 "" RAT_FUNC "%6.3" "uA/V" COEFFS 0 4 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD i_q1_uA "" RAT_FUNC "%6.2" "uA" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD i_ub_q0p04 "" RAT_FUNC "%6.4" "A" COEFFS 0 1 0 0 0 0.04 /end COMPU_METHOD
/begin COMPU_METHOD Kd "" RAT_FUNC "%7.6" "1/1" COEFFS 0 65536 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD Kd_1 "" RAT_FUNC "%6.4" "1/1" COEFFS 0 512 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD Kd_Lin_16 "" RAT_FUNC "%7.6" "1/1" COEFFS 0 32767 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD Kd_pRail2Q_1 "" RAT_FUNC "%7.6" "mm^3/s/hPa" COEFFS 0 40960 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD Kd_Prc_COMPU "" RAT_FUNC "%6.5" "%" COEFFS 0 8000 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD Ki "" RAT_FUNC "%6.5" "1/s" COEFFS 0 2147.483648 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD Ki_1 "" RAT_FUNC "%6.4" "1/s" COEFFS 0 67.108864 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD Ki_LamCtl "" RAT_FUNC "%6.4" "-" COEFFS 0 262.144 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD Ki_pRail2Q_1 "" RAT_FUNC "%7.6" "mm^3/s^2/hPa" COEFFS 0 10737.41824 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD Ki_Temp2EGTFact "" RAT_FUNC "%8.7" "-" COEFFS 0 429496.7296 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD Kp "" RAT_FUNC "%7.6" "1/1" COEFFS 0 32768 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD Kp_1 "" RAT_FUNC "%6.4" "1/1" COEFFS 0 64 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD Kp_LmbdRec2InjMass_1 "" RAT_FUNC "%6.4" "mg/stroke" COEFFS 0 81.92 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD Kp_pRail2Q_1 "" RAT_FUNC "%7.6" "mm^3/s/hPa" COEFFS 0 81920 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD Kp_Temp2EGTFact "" RAT_FUNC "%7.6" "-" COEFFS 0 25600 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD kw_q0p1 "" RAT_FUNC "%6.3" "Grad KW" COEFFS 0 10 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD kw_q1 "" RAT_FUNC "%6.2" "Grad KW" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD L9929_SY_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF L9929_SY_Compu /end COMPU_METHOD
/begin COMPU_VTAB L9929_SY_Compu "" TAB_VERB 2 0 "no L9929" 1 "one L9929" /end COMPU_VTAB
/begin COMPU_METHOD lambdaRec "" RAT_FUNC "%7.6" "-" COEFFS 0 10000 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD lambdaRecVal "" RAT_FUNC "%6.5" "-" COEFFS 0 1000 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD Lambda_DiffQuot "" RAT_FUNC "%6.4" "1/s" COEFFS 0 20 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD LAMCORENGTEMP_SY_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF LAMCORENGTEMP_SY_Compu /end COMPU_METHOD
/begin COMPU_VTAB LAMCORENGTEMP_SY_Compu "" TAB_VERB 2 0 "False" 1 "True" /end COMPU_VTAB
/begin COMPU_METHOD LengthCpp "" RAT_FUNC "%8.7" "m" COEFFS 0 100000 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD LengthFine "" RAT_FUNC "%6.5" "m" COEFFS 0 1000 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD LengthKm "" RAT_FUNC "%6.1" "Km" COEFFS 0 0.05 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD LengthKm1 "" RAT_FUNC "%6.2" "Km" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD LengthKmFine "" RAT_FUNC "%6.3" "Km" COEFFS 0 10 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD Length_fine "" RAT_FUNC "%6.5" "m" COEFFS 0 1000 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD Len_Km_q0p00001_COMPU "" RAT_FUNC "%8.7" "Km" COEFFS 0 100000 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD LSM_SY_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF LSM_SY_Compu /end COMPU_METHOD
/begin COMPU_VTAB LSM_SY_Compu "" TAB_VERB 2 0 "0" 1 "1" /end COMPU_VTAB
/begin COMPU_METHOD LSUADV_SY_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF LSUADV_SY_Compu /end COMPU_METHOD
/begin COMPU_VTAB LSUADV_SY_Compu "" TAB_VERB 2 0 "False" 1 "True" /end COMPU_VTAB
/begin COMPU_METHOD LSUDLYFLT_SY_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF LSUDLYFLT_SY_Compu /end COMPU_METHOD
/begin COMPU_VTAB LSUDLYFLT_SY_Compu "" TAB_VERB 2 0 "False" 1 "True" /end COMPU_VTAB
/begin COMPU_METHOD LSUHTRCPLMON_SY_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF LSUHTRCPLMON_SY_Compu /end COMPU_METHOD
/begin COMPU_VTAB LSUHTRCPLMON_SY_Compu "" TAB_VERB 2 0 "False" 1 "True" /end COMPU_VTAB
/begin COMPU_METHOD LSU_CT_SENSORS_SY_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF LSU_CT_SENSORS_SY_Compu /end COMPU_METHOD
/begin COMPU_VTAB LSU_CT_SENSORS_SY_Compu "" TAB_VERB 4 1 "1" 2 "2" 3 "3" 4 "4" /end COMPU_VTAB
/begin COMPU_METHOD Mass "" RAT_FUNC "%6.2" "-" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD Mass2Temp_q0p000003 "" RAT_FUNC "%8.7" "Kg/K" COEFFS 0 333333.333333333 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD MassPerTimeq0p00001 "" RAT_FUNC "%8.7" "g/s" COEFFS 0 100000 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD MassPerTimeq0p001 "" RAT_FUNC "%6.5" "g/s" COEFFS 0 1000 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD Mass_q1 "" RAT_FUNC "%6.2" "g" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD MAX_NUM_ADDINJ_SY_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF MAX_NUM_ADDINJ_SY_Compu /end COMPU_METHOD
/begin COMPU_VTAB MAX_NUM_ADDINJ_SY_Compu "" TAB_VERB 2 0 "0" 1 "1" /end COMPU_VTAB
/begin COMPU_METHOD MAX_NUM_MAININJ_SY_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF MAX_NUM_MAININJ_SY_Compu /end COMPU_METHOD
/begin COMPU_VTAB MAX_NUM_MAININJ_SY_Compu "" TAB_VERB 3 2 "2" 3 "3" 4 "4" /end COMPU_VTAB
/begin COMPU_METHOD MFVLV_CDRVCALCENBL_SY_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF MFVLV_CDRVCALCENBL_SY_Compu /end COMPU_METHOD
/begin COMPU_VTAB MFVLV_CDRVCALCENBL_SY_Compu "" TAB_VERB 2 0 "MFVLV_DISABLE" 1 "MFVLV_ENABLE" /end COMPU_VTAB
/begin COMPU_METHOD MFVLV_CY202_SY_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF MFVLV_CY202_SY_Compu /end COMPU_METHOD
/begin COMPU_VTAB MFVLV_CY202_SY_Compu "" TAB_VERB 4 0 "kein CY202" 1 "ein CY202" 2 "zwei CY202" 3 "drei CY202" /end COMPU_VTAB
/begin COMPU_METHOD MgPerHubSec "" RAT_FUNC "%6.3" "mg/(Hub*sec)" COEFFS 0 10 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD MILLMP_PWRSTG_SY_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF MILLMP_PWRSTG_SY_Compu /end COMPU_METHOD
/begin COMPU_VTAB MILLMP_PWRSTG_SY_Compu "" TAB_VERB 2 0 "False" 1 "True" /end COMPU_VTAB
/begin COMPU_METHOD MILLMP_SUPRT_ATS_SY_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF MILLMP_SUPRT_ATS_SY_Compu /end COMPU_METHOD
/begin COMPU_VTAB MILLMP_SUPRT_ATS_SY_Compu "" TAB_VERB 2 0 "False" 1 "True" /end COMPU_VTAB
/begin COMPU_METHOD mOilAsh_g "" RAT_FUNC "%6.4" "g" COEFFS 0 100 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD Molmass "" RAT_FUNC "%6.4" "g/mol" COEFFS 0 100 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD MSI_SY_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF MSI_SY_Compu /end COMPU_METHOD
/begin COMPU_VTAB MSI_SY_Compu "" TAB_VERB 2 0 "0" 1 "1" /end COMPU_VTAB
/begin COMPU_METHOD MSI_TMPR_SY_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF MSI_TMPR_SY_Compu /end COMPU_METHOD
/begin COMPU_VTAB MSI_TMPR_SY_Compu "" TAB_VERB 2 0 "False" 1 "True" /end COMPU_VTAB
/begin COMPU_METHOD mSoot_g "" RAT_FUNC "%6.4" "g" COEFFS 0 100 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD MsPerVol "" RAT_FUNC "%6.5" "g/l" COEFFS 0 1000 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD MsPrTime_mgprsec_q0p1_COMPU "" RAT_FUNC "%6.3" "mg/s" COEFFS 0 10 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD Ms_g_q0p001_COMPU "" RAT_FUNC "%6.5" "g" COEFFS 0 1000 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD Ms_kg_COMPU "" RAT_FUNC "%6.4" "kg" COEFFS 0 100 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD Ms_O2 "" RAT_FUNC "%6.5" "g" COEFFS 0 1000 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD Ms_O2_Fine "" RAT_FUNC "%8.7" "g" COEFFS 0 100000 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD Ms_SOx "" RAT_FUNC "%6.5" "g" COEFFS 0 3278.68852459016 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD Ms_SOxLdTot "" RAT_FUNC "%6.3" "mg" COEFFS 0 2 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD Ms_SOxNOx "" RAT_FUNC "%8.7" "g" COEFFS 0 100000 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD M_NOxLd_LoRes "" RAT_FUNC "%6.4" "g" COEFFS 0 250 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD M_NOxMsSOx "" RAT_FUNC "%6.5" "g" COEFFS 0 3276.8 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD m_q0p0peri4 "" RAT_FUNC "%6.4" "g" COEFFS 0 45 0 0 0 2 /end COMPU_METHOD
/begin COMPU_METHOD m_q2p777Em5_kg "" RAT_FUNC "%7.6" "kg" COEFFS 0 3600 0 0 0 0.1 /end COMPU_METHOD
/begin COMPU_METHOD m_q5p5555Em5_kg_DIV_s "" RAT_FUNC "%7.6" "kg/s" COEFFS 0 18000 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD m_uw_b6553p5 "" RAT_FUNC "%6.3" "kg/h" COEFFS 0 1 0 0 0 0.1 /end COMPU_METHOD
/begin COMPU_METHOD nmot_q0p5 "" RAT_FUNC "%6.3" "1/min" COEFFS 0 2 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD nmot_sw_q0p5 "" RAT_FUNC "%6.3" "1/min" COEFFS 0 2 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD nmot_ub_q40 "" RAT_FUNC "%6.1" "1/min" COEFFS 0 1 0 0 0 40 /end COMPU_METHOD
/begin COMPU_METHOD NmPerSec "" RAT_FUNC "%6.3" "Nm/s" COEFFS 0 10 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD nox "" RAT_FUNC "%6.2" "kg/m" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD NOxFlwEG "" RAT_FUNC "%6.4" "Gram/s" COEFFS 0 40 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD NOxLdPerFl "" RAT_FUNC "%6.5" "1/l" COEFFS 0 8192 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD NOxMassFlw "" RAT_FUNC "%6.5" "mg/s" COEFFS 0 1000 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD NOxMassPerTime "" RAT_FUNC "%6.3" "mg/s" COEFFS 0 10 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD NSCRgn_Time_S "" RAT_FUNC "%6.4" "s" COEFFS 0 100 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD NSC_CT_SENSORS_SY_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF NSC_CT_SENSORS_SY_Compu /end COMPU_METHOD
/begin COMPU_VTAB NSC_CT_SENSORS_SY_Compu "" TAB_VERB 5 0 "ZERO" 1 "ONE" 2 "TWO" 3 "THREE" 4 "FOUR" /end COMPU_VTAB
/begin COMPU_METHOD NUMCYLACT_SY_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF NUMCYLACT_SY_Compu /end COMPU_METHOD
/begin COMPU_VTAB NUMCYLACT_SY_Compu "" TAB_VERB 8 2 "2 cylinder" 3 "3 cylinder" 4 "4 cylinder" 5 "5 cylinder" 6 "6 cylinder" 8 "8 cylinder" 10 "10 cylinder" 12 "12 cylinder" /end COMPU_VTAB
/begin COMPU_METHOD NUMCYLCAL_SY_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF NUMCYLCAL_SY_Compu /end COMPU_METHOD
/begin COMPU_VTAB NUMCYLCAL_SY_Compu "" TAB_VERB 2 0 "fixed cyl-number" 1 "cyl-number calibratable" /end COMPU_VTAB
/begin COMPU_METHOD NUMCYLMAX_SY_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF NUMCYLMAX_SY_Compu /end COMPU_METHOD
/begin COMPU_VTAB NUMCYLMAX_SY_Compu "" TAB_VERB 8 2 "2 cylinder" 3 "3 cylinder" 4 "4 cylinder" 5 "5 cylinder" 6 "6 cylinder" 8 "8 cylinder" 10 "10 cylinder" 12 "12 cylinder" /end COMPU_VTAB
/begin COMPU_METHOD NUMFANS_SY_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF NUMFANS_SY_Compu /end COMPU_METHOD
/begin COMPU_VTAB NUMFANS_SY_Compu "" TAB_VERB 5 0 "0" 1 "1" 2 "2" 3 "3" 12 "12" /end COMPU_VTAB
/begin COMPU_METHOD NUMPSICBNK_SY_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF NUMPSICBNK_SY_Compu /end COMPU_METHOD
/begin COMPU_VTAB NUMPSICBNK_SY_Compu "" TAB_VERB 4 1 "1" 2 "2" 3 "3" 4 "4" /end COMPU_VTAB
/begin COMPU_METHOD NUMPSICCHP_SY_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF NUMPSICCHP_SY_Compu /end COMPU_METHOD
/begin COMPU_VTAB NUMPSICCHP_SY_Compu "" TAB_VERB 2 1 "1" 2 "2" /end COMPU_VTAB
/begin COMPU_METHOD O2 "" RAT_FUNC "%8.7" "-" COEFFS 0 100000 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD O2MassPerTime "" RAT_FUNC "%6.4" "Kg/h" COEFFS 0 100 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD O2MassPerTimeLo "" RAT_FUNC "%6.4" "Kg/h" COEFFS 0 50 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD OBD_PHYSMEDM_SY_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF OBD_PHYSMEDM_SY_Compu /end COMPU_METHOD
/begin COMPU_VTAB OBD_PHYSMEDM_SY_Compu "" TAB_VERB 2 0 "OBD_PHYSMEDM_CAN" 1 "OBD_PHYSMEDM_KLINE" /end COMPU_VTAB
/begin COMPU_METHOD OBS_SY_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF OBS_SY_Compu /end COMPU_METHOD
/begin COMPU_VTAB OBS_SY_Compu "" TAB_VERB 2 0 "NOOBS" 1 "SMP480" /end COMPU_VTAB
/begin COMPU_METHOD OilMassPerTime "" RAT_FUNC "%7.6" "mg/s" COEFFS 0 10000 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD OilMassPerTimeLo "" RAT_FUNC "%6.4" "mg/s" COEFFS 0 500 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD OilMFl_mgps_q0p1 "" RAT_FUNC "%6.3" "mg/s" COEFFS 0 10 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD OilMsPrc_q0p01 "" RAT_FUNC "%6.4" "%" COEFFS 0 100 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD OilMs_mg "" RAT_FUNC "%6.2" "mg" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD OilMs_q0p1 "" RAT_FUNC "%6.3" "g" COEFFS 0 10 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD OilMs_q10 "" RAT_FUNC "%6.1" "g" COEFFS 0 0.1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD Oil_lvl_mm_q0p004 "" RAT_FUNC "%6.4" "mm" COEFFS 0 250 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD OneToOne "" RAT_FUNC "%6.2" "No Unit" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD OneToOne_ms "" RAT_FUNC "%6.2" "ms" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD OneToOne_us "" RAT_FUNC "%6.2" "us" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD OneToTenCarb "" RAT_FUNC "%6.1" "-" COEFFS 0 0.1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD OSTYPE_SY_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF OSTYPE_SY_Compu /end COMPU_METHOD
/begin COMPU_VTAB OSTYPE_SY_Compu "" TAB_VERB 2 0 "ERCOSEK-OS" 1 "RTA-OS" /end COMPU_VTAB
/begin COMPU_METHOD OXSENSDYNADAP_SY_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF OXSENSDYNADAP_SY_Compu /end COMPU_METHOD
/begin COMPU_VTAB OXSENSDYNADAP_SY_Compu "" TAB_VERB 2 0 "False" 1 "True" /end COMPU_VTAB
/begin COMPU_METHOD PCA8565_SY_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF PCA8565_SY_Compu /end COMPU_METHOD
/begin COMPU_VTAB PCA8565_SY_Compu "" TAB_VERB 2 0 "no PCA8565" 1 "one PCA8565" /end COMPU_VTAB
/begin COMPU_METHOD PCP_SY_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF PCP_SY_Compu /end COMPU_METHOD
/begin COMPU_VTAB PCP_SY_Compu "" TAB_VERB 2 0 "no PCP" 1 "PCP present" /end COMPU_VTAB
/begin COMPU_METHOD rel_uw_b200 "" RAT_FUNC "%6.4" "%" COEFFS 0 65536 0 0 0 200 /end COMPU_METHOD
/begin COMPU_METHOD rpspg_q0p0156 "" RAT_FUNC "%6.4" "Ohm/V" COEFFS 0 65536 0 0 0 1024 /end COMPU_METHOD
/begin COMPU_METHOD r_q0p0391 "" RAT_FUNC "%6.4" "Ohm" COEFFS 0 65536 0 0 0 2560 /end COMPU_METHOD
/begin COMPU_METHOD r_q0p15625 "" RAT_FUNC "%6.3" "Ohm" COEFFS 0 65536 0 0 0 10240 /end COMPU_METHOD
/begin COMPU_METHOD r_uw_q2 "" RAT_FUNC "%6.2" "Ohm" COEFFS 0 1 0 0 0 2 /end COMPU_METHOD
/begin COMPU_METHOD Signals_IntSigNumVerb "" TAB_VERB "%6.3" "" COMPU_TAB_REF Signals_IntSigNumVerb /end COMPU_METHOD
/begin COMPU_VTAB Signals_IntSigNumVerb "" TAB_VERB 37 0 "SIGNALS_Signals_Default" 1 "SIGNALS_EpmCaS_phiOfsCorr" 2 "SIGNALS_EpmCaS_phiOfsCorr_2" 3 "SIGNALS_EpmCaS_phiOfsCorr_3" 4 "SIGNALS_EpmCaS_phiOfsCorr_4" 5 "SIGNALS_Epm_nEng" 6 "SIGNALS_Epm_stOpMode" 7 "SIGNALS_Epm_stSync" 8 "SIGNALS_I15031_FILLSIG1h" 9 "SIGNALS_I15031_FILLSIG2h" 10 "SIGNALS_I15031_FILLSIG4h" 11 "SIGNALS_PID01h" 12 "SIGNALS_PID14h_0" 13 "SIGNALS_PID15h_0" 14 "SIGNALS_PID16h_0" 15 "SIGNALS_PID18h_0" 16 "SIGNALS_PID19h_0" 17 "SIGNALS_PID1Ah_0" 18 "SIGNALS_PID1Ch" 19 "SIGNALS_PID21h" 20 "SIGNALS_PID30h" 21 "SIGNALS_PID31h" 22 "SIGNALS_PID34h_0" 23 "SIGNALS_PID34h_1" 24 "SIGNALS_PID38h_0" 25 "SIGNALS_PID38h_1" 26 "SIGNALS_PID41h" 27 "SIGNALS_PID4FAh" 28 "SIGNALS_PID4FBh" 29 "SIGNALS_PID4FCh" 30 "SIGNALS_PID4FDh" 31 "SIGNALS_PID50Ah" 32 "SIGNALS_PID50Bh" 33 "SIGNALS_PID50Ch" 34 "SIGNALS_PID50Dh" 35 "SIGNALS_PID5Fh" 36 "SIGNALS_T15_stRaw" /end COMPU_VTAB
/begin COMPU_METHOD spg_q0p00039 "" RAT_FUNC "%6.5" "V" COEFFS 0 1 0 0 0 0.000390625 /end COMPU_METHOD
/begin COMPU_METHOD spg_q0p00488 "" RAT_FUNC "%6.4" "V" COEFFS 0 1024 0 0 0 5 /end COMPU_METHOD
/begin COMPU_METHOD spg_q0p1 "" RAT_FUNC "%6.3" "V" COEFFS 0 1 0 0 0 0.1 /end COMPU_METHOD
/begin COMPU_METHOD spg_q4p88Em4 "" RAT_FUNC "%6.5" "V" COEFFS 0 2048 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD spg_sw_q0p0001 "" RAT_FUNC "%6.5" "V" COEFFS 0 32768 0 0 0 3.3 /end COMPU_METHOD
/begin COMPU_METHOD spg_uw_q0p00488 "" RAT_FUNC "%6.4" "V" COEFFS 0 1024 0 0 0 5 /end COMPU_METHOD
/begin COMPU_METHOD spg_uw_q0p00488_o1 "" RAT_FUNC "%6.3" "V" COEFFS 0 1024 1024 0 0 5 /end COMPU_METHOD
/begin COMPU_METHOD SyC_Time_100ms "" RAT_FUNC "%6.3" "s" COEFFS 0 1000 0 0 0 100 /end COMPU_METHOD
/begin COMPU_METHOD t100msxs_uw_b6553p5 "" RAT_FUNC "%6.3" "s" COEFFS 0 1 0 0 0 0.1 /end COMPU_METHOD
/begin COMPU_METHOD t1sxs_q1 "" RAT_FUNC "%6.2" "s" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD TaskCycleFieldSelRx "" TAB_VERB "%6.3" "" COMPU_TAB_REF TaskCycleFieldSelRx /end COMPU_METHOD
/begin COMPU_VTAB TaskCycleFieldSelRx "" TAB_VERB 5 0 "FRMSCH_RXMODE1" 1 "FRMSCH_RXMODE2" 2 "FRMSCH_RXMODE3" 3 "FRMSCH_RXMODE4" 4 "FRMSCH_RXMODE5" /end COMPU_VTAB
/begin COMPU_METHOD TaskCycleFieldSelTx "" TAB_VERB "%6.3" "" COMPU_TAB_REF TaskCycleFieldSelTx /end COMPU_METHOD
/begin COMPU_VTAB TaskCycleFieldSelTx "" TAB_VERB 5 0 "FRMSCH_TXMODE1" 1 "FRMSCH_TXMODE2" 2 "FRMSCH_TXMODE3" 3 "FRMSCH_TXMODE4" 4 "FRMSCH_TXMODE5" /end COMPU_VTAB
/begin COMPU_METHOD TempDiff_Kelv "" RAT_FUNC "%6.3" "K" COEFFS 0 10 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD Temp_Cels "" RAT_FUNC "%6.1" "deg C" COEFFS 0 10 2731.4 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD temp_q0p0234_o273 "" RAT_FUNC "%6.1" "Grad C" COEFFS 0 1 273.15 0 0 0.0234375 /end COMPU_METHOD
/begin COMPU_METHOD temp_q0p0234_om273 "" RAT_FUNC "%6.1" "Grad C" COEFFS 0 640 174816 0 0 15 /end COMPU_METHOD
/begin COMPU_METHOD TimeDeb "" RAT_FUNC "%6.1" "ms" COEFFS 0 0.1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD Time_ms "" RAT_FUNC "%6.1" "ms" COEFFS 0 0.1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD Time_sec_q1_COMPU "" RAT_FUNC "%6.2" "s" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD Time_usec_q1_COMPU "" RAT_FUNC "%6.2" "us" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD Trq "" RAT_FUNC "%6.3" "Nm" COEFFS 0 10 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD t_q0p01 "" RAT_FUNC "%6.4" "s" COEFFS 0 100 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD t_q0p1 "" RAT_FUNC "%6.3" "s" COEFFS 0 10 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD t_q1 "" RAT_FUNC "%6.2" "s" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD Volt "" RAT_FUNC "%6.3" "mV" COEFFS 0 5 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD VoltToRes "" RAT_FUNC "%6.5" "Ohm/mV" COEFFS 0 2000 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD zk100msxs_uw_b6553p6 "" RAT_FUNC "%6.1" "s" COEFFS 0 0 65536 0 10 0 /end COMPU_METHOD
/begin COMPU_METHOD zk1msxs_uw_b65p536 "" RAT_FUNC "%6.3" "s" COEFFS 0 0 65536 0 1000 0 /end COMPU_METHOD
/begin COMPU_METHOD default "" RAT_FUNC "%6.2" "" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD defaultAscii "" RAT_FUNC "%6.2" "" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin RECORD_LAYOUT Axis_Xs16 NO_AXIS_PTS_X 1 SWORD AXIS_PTS_X 2 SWORD INDEX_INCR DIRECT /end RECORD_LAYOUT
/begin RECORD_LAYOUT CurG_Ws16 FNC_VALUES 1 SWORD COLUMN_DIR DIRECT /end RECORD_LAYOUT
/begin RECORD_LAYOUT Cur_Xs16Ws16 NO_AXIS_PTS_X 1 SWORD AXIS_PTS_X 2 SWORD INDEX_INCR DIRECT FNC_VALUES 3 SWORD COLUMN_DIR DIRECT /end RECORD_LAYOUT
/begin RECORD_LAYOUT KfAxU8AyU8SstxU16SstyU16WU16 NO_AXIS_PTS_X 1 UWORD NO_AXIS_PTS_Y 2 UWORD AXIS_PTS_X 3 UWORD INDEX_INCR DIRECT AXIS_PTS_Y 4 UWORD INDEX_INCR DIRECT FNC_VALUES 5 UWORD COLUMN_DIR DIRECT /end RECORD_LAYOUT
/begin RECORD_LAYOUT KlAxU8SstxS16WU16 NO_AXIS_PTS_X 1 UWORD AXIS_PTS_X 2 SWORD INDEX_INCR DIRECT FNC_VALUES 3 UWORD COLUMN_DIR DIRECT /end RECORD_LAYOUT
/begin RECORD_LAYOUT KlAxU8SstxU16WU16 NO_AXIS_PTS_X 1 UWORD AXIS_PTS_X 2 UWORD INDEX_INCR DIRECT FNC_VALUES 3 UWORD COLUMN_DIR DIRECT /end RECORD_LAYOUT
/begin RECORD_LAYOUT KwbUw FNC_VALUES 1 UWORD COLUMN_DIR DIRECT /end RECORD_LAYOUT
/begin RECORD_LAYOUT KwbWS16 FNC_VALUES 1 SWORD COLUMN_DIR DIRECT /end RECORD_LAYOUT
/begin RECORD_LAYOUT KwSw FNC_VALUES 1 SWORD COLUMN_DIR DIRECT /end RECORD_LAYOUT
/begin RECORD_LAYOUT KwUb FNC_VALUES 1 UBYTE COLUMN_DIR DIRECT /end RECORD_LAYOUT
/begin RECORD_LAYOUT KwWS16 FNC_VALUES 1 SWORD COLUMN_DIR DIRECT /end RECORD_LAYOUT
/begin RECORD_LAYOUT KwWU16 FNC_VALUES 1 UWORD COLUMN_DIR DIRECT /end RECORD_LAYOUT
/begin RECORD_LAYOUT KwWU8 FNC_VALUES 1 UBYTE COLUMN_DIR DIRECT /end RECORD_LAYOUT
/begin RECORD_LAYOUT Kw_Ws16 FNC_VALUES 1 SWORD COLUMN_DIR DIRECT /end RECORD_LAYOUT
/begin RECORD_LAYOUT Kw_Wu8 FNC_VALUES 1 UBYTE COLUMN_DIR DIRECT /end RECORD_LAYOUT
/begin RECORD_LAYOUT ValA_Ws16 FNC_VALUES 1 SWORD COLUMN_DIR DIRECT /end RECORD_LAYOUT
/begin RECORD_LAYOUT ValA_Ws32 FNC_VALUES 1 SLONG COLUMN_DIR DIRECT /end RECORD_LAYOUT
/begin RECORD_LAYOUT ValA_Wu16 FNC_VALUES 1 UWORD COLUMN_DIR DIRECT /end RECORD_LAYOUT
/begin RECORD_LAYOUT ValA_Wu8 FNC_VALUES 1 UBYTE COLUMN_DIR DIRECT /end RECORD_LAYOUT
/begin RECORD_LAYOUT Val_Ws16 FNC_VALUES 1 SWORD COLUMN_DIR DIRECT /end RECORD_LAYOUT
/begin RECORD_LAYOUT Val_Ws32 FNC_VALUES 1 SLONG COLUMN_DIR DIRECT /end RECORD_LAYOUT
/begin RECORD_LAYOUT Val_Ws8 FNC_VALUES 1 SBYTE COLUMN_DIR DIRECT /end RECORD_LAYOUT
/begin RECORD_LAYOUT Val_Wu16 FNC_VALUES 1 UWORD COLUMN_DIR DIRECT /end RECORD_LAYOUT
/begin RECORD_LAYOUT Val_Wu32 FNC_VALUES 1 ULONG COLUMN_DIR DIRECT /end RECORD_LAYOUT
/begin RECORD_LAYOUT Val_Wu8 FNC_VALUES 1 UBYTE COLUMN_DIR DIRECT /end RECORD_LAYOUT
/end MODULE
/end PROJECT
