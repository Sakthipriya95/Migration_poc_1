ASAP2_VERSION 1 4
/begin PROJECT MED1734_Flx_G1 "MEDC17_Core"
/begin HEADER "" VERSION "MED1734_Flx_01" PROJECT_NO MED1734_Flx_G1 /end HEADER
/begin MODULE DIM ""
/begin MOD_COMMON "" BYTE_ORDER MSB_LAST ALIGNMENT_BYTE 1 ALIGNMENT_WORD 2 ALIGNMENT_LONG 4 ALIGNMENT_FLOAT32_IEEE 4 /end MOD_COMMON
/begin CHARACTERISTIC DFES_DTCO.DFC_Cy320SpiCom_C "DFC / OBD specific diagnostic trouble code for check DFCy320SpiCom_C" VALUE 0x80283E5A Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_MonUMaxSupply1_C "DFC / OBD specific diagnostic trouble code for check DFC_MonUMaxSupply1" VALUE 0x80283E5C Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_MonUMaxSupply2_C "DFC / OBD specific diagnostic trouble code for check DFC_MonUMaxSupply2" VALUE 0x80283E5E Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_MonUMaxSupply3_C "DFC / OBD specific diagnostic trouble code for check DFC_MonUMaxSupply3" VALUE 0x80283E60 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_MonUMinSupply1_C "DFC / OBD specific diagnostic trouble code for check DFC_MonUMinSupply1" VALUE 0x80283E62 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_MonUMinSupply2_C "DFC / OBD specific diagnostic trouble code for check DFC_MonUMinSupply2" VALUE 0x80283E64 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_MonUMinSupply3_C "DFC / OBD specific diagnostic trouble code for check DFC_MonUMinSupply3" VALUE 0x80283E66 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_SSpMon1_C "DFC / OBD specific diagnostic trouble code for check DFC_SSpMon1" VALUE 0x80283E68 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_SSpMon1OV_C "DFC / OBD specific diagnostic trouble code for check DFC_SSpMon1OV" VALUE 0x80283E6A Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_SSpMon1UV_C "DFC / OBD specific diagnostic trouble code for check DFC_SSpMon1UV" VALUE 0x80283E6C Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_SSpMon2_C "DFC / OBD specific diagnostic trouble code for check DFC_SSpMon2" VALUE 0x80283E6E Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_SSpMon2OV_C "DFC / OBD specific diagnostic trouble code for check DFC_SSpMon2OV" VALUE 0x80283E70 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_SSpMon2UV_C "DFC / OBD specific diagnostic trouble code for check DFC_SSpMon2UV" VALUE 0x80283E72 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_SSpMon3_C "DFC / OBD specific diagnostic trouble code for check DFC_SSpMon3" VALUE 0x80283E74 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_SSpMon3OV_C "DFC / OBD specific diagnostic trouble code for check DFC_SSpMon3OV" VALUE 0x80283E76 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_SSpMon3UV_C "DFC / OBD specific diagnostic trouble code for check DFC_SSpMon3UV" VALUE 0x80283E78 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_HDEVK_MIN_0_C "DFC / OBD specific diagnostic trouble code for check DFC_HDEVK_MIN_0" VALUE 0x80283E7A Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_HDEVK_MIN_1_C "DFC / OBD specific diagnostic trouble code for check DFC_HDEVK_MIN_1" VALUE 0x80283E7C Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_HDEVK_NPL_0_C "DFC / OBD specific diagnostic trouble code for check DFC_HDEVK_NPL_0" VALUE 0x80283E7E Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_HDEVK_NPL_1_C "DFC / OBD specific diagnostic trouble code for check DFC_HDEVK_NPL_1" VALUE 0x80283E80 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_HDEVK_SIG_0_C "DFC / OBD specific diagnostic trouble code for check DFC_HDEVK_SIG_0" VALUE 0x80283E82 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_HDEVK_SIG_1_C "DFC / OBD specific diagnostic trouble code for check DFC_HDEVK_SIG_1" VALUE 0x80283E84 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_IgnClPsClOpen0_C "DFC / OBD specific diagnostic trouble code for check DFC_IgnClPsClOpen0" VALUE 0x80283E86 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_IgnClPsClOpen1_C "DFC / OBD specific diagnostic trouble code for check DFC_IgnClPsClOpen1" VALUE 0x80283E88 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_IgnClPsClOpen2_C "DFC / OBD specific diagnostic trouble code for check DFC_IgnClPsClOpen2" VALUE 0x80283E8A Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_IgnClPsClOpen3_C "DFC / OBD specific diagnostic trouble code for check DFC_IgnClPsClOpen3" VALUE 0x80283E8C Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_IgnClPsClOpen4_C "DFC / OBD specific diagnostic trouble code for check DFC_IgnClPsClOpen4" VALUE 0x80283E8E Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_IgnClPsClOpen5_C "DFC / OBD specific diagnostic trouble code for check DFC_IgnClPsClOpen5" VALUE 0x80283E90 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_IgnClPsClOpen6_C "DFC / OBD specific diagnostic trouble code for check DFC_IgnClPsClOpen6" VALUE 0x80283E92 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_IgnClPsClOpen7_C "DFC / OBD specific diagnostic trouble code for check DFC_IgnClPsClOpen7" VALUE 0x80283E94 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_IgnClPsClShCir0_C "DFC / OBD specific diagnostic trouble code for check DFC_IgnClPsClShCir0" VALUE 0x80283E96 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_IgnClPsClShCir1_C "DFC / OBD specific diagnostic trouble code for check DFC_IgnClPsClShCir1" VALUE 0x80283E98 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_IgnClPsClShCir2_C "DFC / OBD specific diagnostic trouble code for check DFC_IgnClPsClShCir2" VALUE 0x80283E9A Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_IgnClPsClShCir3_C "DFC / OBD specific diagnostic trouble code for check DFC_IgnClPsClShCir3" VALUE 0x80283E9C Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_IgnClPsClShCir4_C "DFC / OBD specific diagnostic trouble code for check DFC_IgnClPsClShCir4" VALUE 0x80283E9E Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_IgnClPsClShCir5_C "DFC / OBD specific diagnostic trouble code for check DFC_IgnClPsClShCir5" VALUE 0x80283EA0 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_IgnClPsClShCir6_C "DFC / OBD specific diagnostic trouble code for check DFC_IgnClPsClShCir6" VALUE 0x80283EA2 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_IgnClPsClShCir7_C "DFC / OBD specific diagnostic trouble code for check DFC_IgnClPsClShCir7" VALUE 0x80283EA4 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_IgnClPsClUnExpt0_C "DFC / OBD specific diagnostic trouble code for check DFC_IgnClPsClUnExpt0" VALUE 0x80283EA6 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_IgnClPsClUnExpt1_C "DFC / OBD specific diagnostic trouble code for check DFC_IgnClPsClUnExpt1" VALUE 0x80283EA8 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_IgnClPsClUnExpt2_C "DFC / OBD specific diagnostic trouble code for check DFC_IgnClPsClUnExpt2" VALUE 0x80283EAA Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_IgnClPsClUnExpt3_C "DFC / OBD specific diagnostic trouble code for check DFC_IgnClPsClUnExpt3" VALUE 0x80283EAC Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_IgnClPsClUnExpt4_C "DFC / OBD specific diagnostic trouble code for check DFC_IgnClPsClUnExpt4" VALUE 0x80283EAE Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_IgnClPsClUnExpt5_C "DFC / OBD specific diagnostic trouble code for check DFC_IgnClPsClUnExpt5" VALUE 0x80283EB0 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_IgnClPsClUnExpt6_C "DFC / OBD specific diagnostic trouble code for check DFC_IgnClPsClUnExpt6" VALUE 0x80283EB2 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_IgnClPsClUnExpt7_C "DFC / OBD specific diagnostic trouble code for check DFC_IgnClPsClUnExpt7" VALUE 0x80283EB4 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_IgnClPsDevIdentErr1_C "DFC / OBD specific diagnostic trouble code for check DFC_IgnClPsDevIdentErr1" VALUE 0x80283EB6 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_IgnClPsDevIdentErr2_C "DFC / OBD specific diagnostic trouble code for check DFC_IgnClPsDevIdentErr2" VALUE 0x80283EB8 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_IgnClPsDevInitErr1_C "DFC / OBD specific diagnostic trouble code for check DFC_IgnClPsDevInitErr1" VALUE 0x80283EBA Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_IgnClPsDevInitErr2_C "DFC / OBD specific diagnostic trouble code for check DFC_IgnClPsDevInitErr2" VALUE 0x80283EBC Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_IgnClPsDevOscErr1_C "DFC / OBD specific diagnostic trouble code for check DFC_IgnClPsDevOscErr1" VALUE 0x80283EBE Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_IgnClPsDevOscErr2_C "DFC / OBD specific diagnostic trouble code for check DFC_IgnClPsDevOscErr2" VALUE 0x80283EC0 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_IgnClPsDevSpiErr1_C "DFC / OBD specific diagnostic trouble code for check DFC_IgnClPsDevSpiErr1" VALUE 0x80283EC2 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_IgnClPsDevSpiErr2_C "DFC / OBD specific diagnostic trouble code for check DFC_IgnClPsDevSpiErr2" VALUE 0x80283EC4 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_IgnClPsOpenLoad0_C "DFC / OBD specific diagnostic trouble code for check DFC_IgnClPsOpenLoad0" VALUE 0x80283EC6 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_IgnClPsOpenLoad1_C "DFC / OBD specific diagnostic trouble code for check DFC_IgnClPsOpenLoad1" VALUE 0x80283EC8 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_IgnClPsOpenLoad2_C "DFC / OBD specific diagnostic trouble code for check DFC_IgnClPsOpenLoad2" VALUE 0x80283ECA Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_IgnClPsOpenLoad3_C "DFC / OBD specific diagnostic trouble code for check DFC_IgnClPsOpenLoad3" VALUE 0x80283ECC Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_IgnClPsOpenLoad4_C "DFC / OBD specific diagnostic trouble code for check DFC_IgnClPsOpenLoad4" VALUE 0x80283ECE Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_IgnClPsOpenLoad5_C "DFC / OBD specific diagnostic trouble code for check DFC_IgnClPsOpenLoad5" VALUE 0x80283ED0 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_IgnClPsOpenLoad6_C "DFC / OBD specific diagnostic trouble code for check DFC_IgnClPsOpenLoad6" VALUE 0x80283ED2 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_IgnClPsOpenLoad7_C "DFC / OBD specific diagnostic trouble code for check DFC_IgnClPsOpenLoad7" VALUE 0x80283ED4 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_IgnClPsShCirBatt0_C "DFC / OBD specific diagnostic trouble code for check DFC_IgnClPsShCirBatt0" VALUE 0x80283ED6 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_IgnClPsShCirBatt1_C "DFC / OBD specific diagnostic trouble code for check DFC_IgnClPsShCirBatt1" VALUE 0x80283ED8 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_IgnClPsShCirBatt2_C "DFC / OBD specific diagnostic trouble code for check DFC_IgnClPsShCirBatt2" VALUE 0x80283EDA Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_IgnClPsShCirBatt3_C "DFC / OBD specific diagnostic trouble code for check DFC_IgnClPsShCirBatt3" VALUE 0x80283EDC Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_IgnClPsShCirBatt4_C "DFC / OBD specific diagnostic trouble code for check DFC_IgnClPsShCirBatt4" VALUE 0x80283EDE Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_IgnClPsShCirBatt5_C "DFC / OBD specific diagnostic trouble code for check DFC_IgnClPsShCirBatt5" VALUE 0x80283EE0 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_IgnClPsShCirBatt6_C "DFC / OBD specific diagnostic trouble code for check DFC_IgnClPsShCirBatt6" VALUE 0x80283EE2 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_IgnClPsShCirBatt7_C "DFC / OBD specific diagnostic trouble code for check DFC_IgnClPsShCirBatt7" VALUE 0x80283EE4 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_IgnClPsShCirGnd0_C "DFC / OBD specific diagnostic trouble code for check DFC_IgnClPsShCirGnd0" VALUE 0x80283EE6 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_IgnClPsShCirGnd1_C "DFC / OBD specific diagnostic trouble code for check DFC_IgnClPsShCirGnd1" VALUE 0x80283EE8 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_IgnClPsShCirGnd2_C "DFC / OBD specific diagnostic trouble code for check DFC_IgnClPsShCirGnd2" VALUE 0x80283EEA Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_IgnClPsShCirGnd3_C "DFC / OBD specific diagnostic trouble code for check DFC_IgnClPsShCirGnd3" VALUE 0x80283EEC Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_IgnClPsShCirGnd4_C "DFC / OBD specific diagnostic trouble code for check DFC_IgnClPsShCirGnd4" VALUE 0x80283EEE Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_IgnClPsShCirGnd5_C "DFC / OBD specific diagnostic trouble code for check DFC_IgnClPsShCirGnd5" VALUE 0x80283EF0 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_IgnClPsShCirGnd6_C "DFC / OBD specific diagnostic trouble code for check DFC_IgnClPsShCirGnd6" VALUE 0x80283EF2 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_IgnClPsShCirGnd7_C "DFC / OBD specific diagnostic trouble code for check DFC_IgnClPsShCirGnd7" VALUE 0x80283EF4 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_KnDetSens1PortAMax_C "DFC / OBD specific diagnostic trouble code for check DFC_KnDetSens1PortAMax" VALUE 0x80283EF6 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_KnDetSens1PortAMin_C "DFC / OBD specific diagnostic trouble code for check DFC_KnDetSens1PortAMin" VALUE 0x80283EF8 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_KnDetSens1PortBMax_C "DFC / OBD specific diagnostic trouble code for check DFC_KnDetSens1PortBMax" VALUE 0x80283EFA Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_KnDetSens1PortBMin_C "DFC / OBD specific diagnostic trouble code for check DFC_KnDetSens1PortBMin" VALUE 0x80283EFC Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_KnDetSens2PortAMax_C "DFC / OBD specific diagnostic trouble code for check DFC_KnDetSens2PortAMax" VALUE 0x80283EFE Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_KnDetSens2PortAMin_C "DFC / OBD specific diagnostic trouble code for check DFC_KnDetSens2PortAMin" VALUE 0x80283F00 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_KnDetSens2PortBMax_C "DFC / OBD specific diagnostic trouble code for check DFC_KnDetSens2PortBMax" VALUE 0x80283F02 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_KnDetSens2PortBMin_C "DFC / OBD specific diagnostic trouble code for check DFC_KnDetSens2PortBMin" VALUE 0x80283F04 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_KnDetSens3PortAMax_C "DFC / OBD specific diagnostic trouble code for check DFC_KnDetSens3PortAMax" VALUE 0x80283F06 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_KnDetSens3PortAMin_C "DFC / OBD specific diagnostic trouble code for check DFC_KnDetSens3PortAMin" VALUE 0x80283F08 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_KnDetSens3PortBMax_C "DFC / OBD specific diagnostic trouble code for check DFC_KnDetSens3PortBMax" VALUE 0x80283F0A Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_KnDetSens3PortBMin_C "DFC / OBD specific diagnostic trouble code for check DFC_KnDetSens3PortBMin" VALUE 0x80283F0C Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_KnDetSens4PortAMax_C "DFC / OBD specific diagnostic trouble code for check DFC_KnDetSens4PortAMax" VALUE 0x80283F0E Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_KnDetSens4PortAMin_C "DFC / OBD specific diagnostic trouble code for check DFC_KnDetSens4PortAMin" VALUE 0x80283F10 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_KnDetSens4PortBMax_C "DFC / OBD specific diagnostic trouble code for check DFC_KnDetSens4PortBMax" VALUE 0x80283F12 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_KnDetSens4PortBMin_C "DFC / OBD specific diagnostic trouble code for check DFC_KnDetSens4PortBMin" VALUE 0x80283F14 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_MfPsNonPlausible_C "DFC / OBD specific diagnostic trouble code for check DFC_MfPsNonPlausible" VALUE 0x80283F16 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_MfPsNonPlausible2_C "DFC / OBD specific diagnostic trouble code for check DFC_MfPsNonPlausible2" VALUE 0x80283F18 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_MfPsOpenLoad_C "DFC / OBD specific diagnostic trouble code for check DFC_MfPsOpenLoad" VALUE 0x80283F1A Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_MfPsOpenLoad2_C "DFC / OBD specific diagnostic trouble code for check DFC_MfPsOpenLoad2" VALUE 0x80283F1C Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_MfPsShCirBattLowSide_C "DFC / OBD specific diagnostic trouble code for check DFC_MfPsShCirBattLowSide" VALUE 0x80283F1E Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_MfPsShCirBattLowSide2_C "DFC / OBD specific diagnostic trouble code for check DFC_MfPsShCirBattLowSide2" VALUE 0x80283F20 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_MfPsShCirGndLowSide_C "DFC / OBD specific diagnostic trouble code for check DFC_MfPsShCirGndLowSide" VALUE 0x80283F22 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_MfPsShCirGndLowSide2_C "DFC / OBD specific diagnostic trouble code for check DFC_MfPsShCirGndLowSide2" VALUE 0x80283F24 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_DevLibBattUHi_C "DFC / OBD specific diagnostic trouble code for check DFC_DevLibBattUHi" VALUE 0x80283F26 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_DevLibBattULo_C "DFC / OBD specific diagnostic trouble code for check DFC_DevLibBattULo" VALUE 0x80283F28 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_DSMDummy_C "DFC / OBD specific diagnostic trouble code for check DFC_DSMDummy" VALUE 0x80283F2A Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_EEPEraseErr_C "DFC / OBD specific diagnostic trouble code for check DFC_EEPEraseErr" VALUE 0x80283F2C Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_EEPRdErr_C "DFC / OBD specific diagnostic trouble code for check DFC_EEPRdErr" VALUE 0x80283F2E Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_EEPWrErr_C "DFC / OBD specific diagnostic trouble code for check DFC_EEPWrErr" VALUE 0x80283F30 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_EV1max_C "DFC / OBD specific diagnostic trouble code for check DFC_EV1max" VALUE 0x80283F32 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_EV1min_C "DFC / OBD specific diagnostic trouble code for check DFC_EV1min" VALUE 0x80283F34 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_EV1sig_C "DFC / OBD specific diagnostic trouble code for check DFC_EV1sig" VALUE 0x80283F36 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_EV2max_C "DFC / OBD specific diagnostic trouble code for check DFC_EV2max" VALUE 0x80283F38 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_EV2min_C "DFC / OBD specific diagnostic trouble code for check DFC_EV2min" VALUE 0x80283F3A Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_EV2sig_C "DFC / OBD specific diagnostic trouble code for check DFC_EV2sig" VALUE 0x80283F3C Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_EV3max_C "DFC / OBD specific diagnostic trouble code for check DFC_EV3max" VALUE 0x80283F3E Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_EV3min_C "DFC / OBD specific diagnostic trouble code for check DFC_EV3min" VALUE 0x80283F40 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_EV3sig_C "DFC / OBD specific diagnostic trouble code for check DFC_EV3sig" VALUE 0x80283F42 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_EV4max_C "DFC / OBD specific diagnostic trouble code for check DFC_EV4max" VALUE 0x80283F44 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_EV4min_C "DFC / OBD specific diagnostic trouble code for check DFC_EV4min" VALUE 0x80283F46 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_EV4sig_C "DFC / OBD specific diagnostic trouble code for check DFC_EV4sig" VALUE 0x80283F48 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_EV5max_C "DFC / OBD specific diagnostic trouble code for check DFC_EV5max" VALUE 0x80283F4A Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_EV5min_C "DFC / OBD specific diagnostic trouble code for check DFC_EV5min" VALUE 0x80283F4C Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_EV5sig_C "DFC / OBD specific diagnostic trouble code for check DFC_EV5sig" VALUE 0x80283F4E Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_EV6max_C "DFC / OBD specific diagnostic trouble code for check DFC_EV6max" VALUE 0x80283F50 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_EV6min_C "DFC / OBD specific diagnostic trouble code for check DFC_EV6min" VALUE 0x80283F52 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_EV6sig_C "DFC / OBD specific diagnostic trouble code for check DFC_EV6sig" VALUE 0x80283F54 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_EV7max_C "DFC / OBD specific diagnostic trouble code for check DFC_EV7max" VALUE 0x80283F56 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_EV7min_C "DFC / OBD specific diagnostic trouble code for check DFC_EV7min" VALUE 0x80283F58 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_EV7sig_C "DFC / OBD specific diagnostic trouble code for check DFC_EV7sig" VALUE 0x80283F5A Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_EV8max_C "DFC / OBD specific diagnostic trouble code for check DFC_EV8max" VALUE 0x80283F5C Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_EV8min_C "DFC / OBD specific diagnostic trouble code for check DFC_EV8min" VALUE 0x80283F5E Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_EV8sig_C "DFC / OBD specific diagnostic trouble code for check DFC_EV8sig" VALUE 0x80283F60 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_EpmCaSI1ErrSig_C "DFC / OBD specific diagnostic trouble code for check DFC_EpmCaSI1ErrSig" VALUE 0x80283F62 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_EpmCaSI1NoSigMax_C "DFC / OBD specific diagnostic trouble code for check DFC_EpmCaSI1NoSigMax" VALUE 0x80283F64 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_EpmCaSI1NoSigMin_C "DFC / OBD specific diagnostic trouble code for check DFC_EpmCaSI1NoSigMin" VALUE 0x80283F66 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_EpmCaSI1OfsErr_C "DFC / OBD specific diagnostic trouble code for check DFC_EpmCaSI1OfsErr" VALUE 0x80283F68 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_EpmCaSI2ErrSig_C "DFC / OBD specific diagnostic trouble code for check DFC_EpmCaSI2ErrSig" VALUE 0x80283F6A Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_EpmCaSI2NoSigMax_C "DFC / OBD specific diagnostic trouble code for check DFC_EpmCaSI2NoSigMax" VALUE 0x80283F6C Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_EpmCaSI2NoSigMin_C "DFC / OBD specific diagnostic trouble code for check DFC_EpmCaSI2NoSigMin" VALUE 0x80283F6E Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_EpmCaSI2OfsErr_C "DFC / OBD specific diagnostic trouble code for check DFC_EpmCaSI2OfsErr" VALUE 0x80283F70 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_EpmCaSO1ErrSig_C "DFC / OBD specific diagnostic trouble code for check DFC_EpmCaSO1ErrSig" VALUE 0x80283F72 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_EpmCaSO1NoSigMax_C "DFC / OBD specific diagnostic trouble code for check DFC_EpmCaSO1NoSigMax" VALUE 0x80283F74 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_EpmCaSO1NoSigMin_C "DFC / OBD specific diagnostic trouble code for check DFC_EpmCaSO1NoSigMin" VALUE 0x80283F76 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_EpmCaSO1OfsErr_C "DFC / OBD specific diagnostic trouble code for check DFC_EpmCaSO1OfsErr" VALUE 0x80283F78 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_EpmCaSO2ErrSig_C "DFC / OBD specific diagnostic trouble code for check DFC_EpmCaSO2ErrSig" VALUE 0x80283F7A Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_EpmCaSO2NoSigMax_C "DFC / OBD specific diagnostic trouble code for check DFC_EpmCaSO2NoSigMax" VALUE 0x80283F7C Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_EpmCaSO2NoSigMin_C "DFC / OBD specific diagnostic trouble code for check DFC_EpmCaSO2NoSigMin" VALUE 0x80283F7E Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_EpmCaSO2OfsErr_C "DFC / OBD specific diagnostic trouble code for check DFC_EpmCaSO2OfsErr" VALUE 0x80283F80 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_EpmCrSDGI_C "DFC / OBD specific diagnostic trouble code for check DFC_EpmCrSDGI" VALUE 0x80283F82 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_EpmCrSErrSig_C "DFC / OBD specific diagnostic trouble code for check DFC_EpmCrSErrSig" VALUE 0x80283F84 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_EpmCrSNoSig_C "DFC / OBD specific diagnostic trouble code for check DFC_EpmCrSNoSig" VALUE 0x80283F86 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_HDEVH_MAX_0_C "DFC / OBD specific diagnostic trouble code for check DFC_HDEVH_MAX_0" VALUE 0x80283F88 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_HDEVH_MAX_1_C "DFC / OBD specific diagnostic trouble code for check DFC_HDEVH_MAX_1" VALUE 0x80283F8A Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_HDEVH_MAX_2_C "DFC / OBD specific diagnostic trouble code for check DFC_HDEVH_MAX_2" VALUE 0x80283F8C Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_HDEVH_MAX_3_C "DFC / OBD specific diagnostic trouble code for check DFC_HDEVH_MAX_3" VALUE 0x80283F8E Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_HDEVH_MAX_4_C "DFC / OBD specific diagnostic trouble code for check DFC_HDEVH_MAX_4" VALUE 0x80283F90 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_HDEVH_MAX_5_C "DFC / OBD specific diagnostic trouble code for check DFC_HDEVH_MAX_5" VALUE 0x80283F92 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_HDEVH_MAX_6_C "DFC / OBD specific diagnostic trouble code for check DFC_HDEVH_MAX_6" VALUE 0x80283F94 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_HDEVH_MAX_7_C "DFC / OBD specific diagnostic trouble code for check DFC_HDEVH_MAX_7" VALUE 0x80283F96 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_HDEVH_MIN_0_C "DFC / OBD specific diagnostic trouble code for check DFC_HDEVH_MIN_0" VALUE 0x80283F98 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_HDEVH_MIN_1_C "DFC / OBD specific diagnostic trouble code for check DFC_HDEVH_MIN_1" VALUE 0x80283F9A Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_HDEVH_MIN_2_C "DFC / OBD specific diagnostic trouble code for check DFC_HDEVH_MIN_2" VALUE 0x80283F9C Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_HDEVH_MIN_3_C "DFC / OBD specific diagnostic trouble code for check DFC_HDEVH_MIN_3" VALUE 0x80283F9E Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_HDEVH_MIN_4_C "DFC / OBD specific diagnostic trouble code for check DFC_HDEVH_MIN_4" VALUE 0x80283FA0 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_HDEVH_MIN_5_C "DFC / OBD specific diagnostic trouble code for check DFC_HDEVH_MIN_5" VALUE 0x80283FA2 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_HDEVH_MIN_6_C "DFC / OBD specific diagnostic trouble code for check DFC_HDEVH_MIN_6" VALUE 0x80283FA4 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_HDEVH_MIN_7_C "DFC / OBD specific diagnostic trouble code for check DFC_HDEVH_MIN_7" VALUE 0x80283FA6 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_HDEVH_NPL_0_C "DFC / OBD specific diagnostic trouble code for check DFC_HDEVH_NPL_0" VALUE 0x80283FA8 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_HDEVH_NPL_1_C "DFC / OBD specific diagnostic trouble code for check DFC_HDEVH_NPL_1" VALUE 0x80283FAA Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_HDEVH_NPL_2_C "DFC / OBD specific diagnostic trouble code for check DFC_HDEVH_NPL_2" VALUE 0x80283FAC Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_HDEVH_NPL_3_C "DFC / OBD specific diagnostic trouble code for check DFC_HDEVH_NPL_3" VALUE 0x80283FAE Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_HDEVH_NPL_4_C "DFC / OBD specific diagnostic trouble code for check DFC_HDEVH_NPL_4" VALUE 0x80283FB0 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_HDEVH_NPL_5_C "DFC / OBD specific diagnostic trouble code for check DFC_HDEVH_NPL_5" VALUE 0x80283FB2 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_HDEVH_NPL_6_C "DFC / OBD specific diagnostic trouble code for check DFC_HDEVH_NPL_6" VALUE 0x80283FB4 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_HDEVH_NPL_7_C "DFC / OBD specific diagnostic trouble code for check DFC_HDEVH_NPL_7" VALUE 0x80283FB6 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_HDEVL_MAX_0_C "DFC / OBD specific diagnostic trouble code for check DFC_HDEVL_MAX_0" VALUE 0x80283FB8 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_HDEVL_MAX_1_C "DFC / OBD specific diagnostic trouble code for check DFC_HDEVL_MAX_1" VALUE 0x80283FBA Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_HDEVL_MAX_2_C "DFC / OBD specific diagnostic trouble code for check DFC_HDEVL_MAX_2" VALUE 0x80283FBC Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_HDEVL_MAX_3_C "DFC / OBD specific diagnostic trouble code for check DFC_HDEVL_MAX_3" VALUE 0x80283FBE Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_HDEVL_MAX_4_C "DFC / OBD specific diagnostic trouble code for check DFC_HDEVL_MAX_4" VALUE 0x80283FC0 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_HDEVL_MAX_5_C "DFC / OBD specific diagnostic trouble code for check DFC_HDEVL_MAX_5" VALUE 0x80283FC2 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_HDEVL_MAX_6_C "DFC / OBD specific diagnostic trouble code for check DFC_HDEVL_MAX_6" VALUE 0x80283FC4 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_HDEVL_MAX_7_C "DFC / OBD specific diagnostic trouble code for check DFC_HDEVL_MAX_7" VALUE 0x80283FC6 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_HDEVL_MIN_0_C "DFC / OBD specific diagnostic trouble code for check DFC_HDEVL_MIN_0" VALUE 0x80283FC8 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_HDEVL_MIN_1_C "DFC / OBD specific diagnostic trouble code for check DFC_HDEVL_MIN_1" VALUE 0x80283FCA Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_HDEVL_MIN_2_C "DFC / OBD specific diagnostic trouble code for check DFC_HDEVL_MIN_2" VALUE 0x80283FCC Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_HDEVL_MIN_3_C "DFC / OBD specific diagnostic trouble code for check DFC_HDEVL_MIN_3" VALUE 0x80283FCE Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_HDEVL_MIN_4_C "DFC / OBD specific diagnostic trouble code for check DFC_HDEVL_MIN_4" VALUE 0x80283FD0 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_HDEVL_MIN_5_C "DFC / OBD specific diagnostic trouble code for check DFC_HDEVL_MIN_5" VALUE 0x80283FD2 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_HDEVL_MIN_6_C "DFC / OBD specific diagnostic trouble code for check DFC_HDEVL_MIN_6" VALUE 0x80283FD4 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_HDEVL_MIN_7_C "DFC / OBD specific diagnostic trouble code for check DFC_HDEVL_MIN_7" VALUE 0x80283FD6 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_HDEVL_NPL_0_C "DFC / OBD specific diagnostic trouble code for check DFC_HDEVL_NPL_0" VALUE 0x80283FD8 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_HDEVL_NPL_1_C "DFC / OBD specific diagnostic trouble code for check DFC_HDEVL_NPL_1" VALUE 0x80283FDA Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_HDEVL_NPL_2_C "DFC / OBD specific diagnostic trouble code for check DFC_HDEVL_NPL_2" VALUE 0x80283FDC Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_HDEVL_NPL_3_C "DFC / OBD specific diagnostic trouble code for check DFC_HDEVL_NPL_3" VALUE 0x80283FDE Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_HDEVL_NPL_4_C "DFC / OBD specific diagnostic trouble code for check DFC_HDEVL_NPL_4" VALUE 0x80283FE0 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_HDEVL_NPL_5_C "DFC / OBD specific diagnostic trouble code for check DFC_HDEVL_NPL_5" VALUE 0x80283FE2 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_HDEVL_NPL_6_C "DFC / OBD specific diagnostic trouble code for check DFC_HDEVL_NPL_6" VALUE 0x80283FE4 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_HDEVL_NPL_7_C "DFC / OBD specific diagnostic trouble code for check DFC_HDEVL_NPL_7" VALUE 0x80283FE6 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_HDEVL_SIG_0_C "DFC / OBD specific diagnostic trouble code for check DFC_HDEVL_SIG_0" VALUE 0x80283FE8 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_HDEVL_SIG_1_C "DFC / OBD specific diagnostic trouble code for check DFC_HDEVL_SIG_1" VALUE 0x80283FEA Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_HDEVL_SIG_2_C "DFC / OBD specific diagnostic trouble code for check DFC_HDEVL_SIG_2" VALUE 0x80283FEC Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_HDEVL_SIG_3_C "DFC / OBD specific diagnostic trouble code for check DFC_HDEVL_SIG_3" VALUE 0x80283FEE Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_HDEVL_SIG_4_C "DFC / OBD specific diagnostic trouble code for check DFC_HDEVL_SIG_4" VALUE 0x80283FF0 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_HDEVL_SIG_5_C "DFC / OBD specific diagnostic trouble code for check DFC_HDEVL_SIG_5" VALUE 0x80283FF2 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_HDEVL_SIG_6_C "DFC / OBD specific diagnostic trouble code for check DFC_HDEVL_SIG_6" VALUE 0x80283FF4 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_HDEVL_SIG_7_C "DFC / OBD specific diagnostic trouble code for check DFC_HDEVL_SIG_7" VALUE 0x80283FF6 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_HSFE2max_C "DFC / OBD specific diagnostic trouble code for check DFC_HSFE2max" VALUE 0x80283FF8 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_HSFE2min_C "DFC / OBD specific diagnostic trouble code for check DFC_HSFE2min" VALUE 0x80283FFA Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_HSFE2sig_C "DFC / OBD specific diagnostic trouble code for check DFC_HSFE2sig" VALUE 0x80283FFC Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_HSFEmax_C "DFC / OBD specific diagnostic trouble code for check DFC_HSFEmax" VALUE 0x80283FFE Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_HSFEmin_C "DFC / OBD specific diagnostic trouble code for check DFC_HSFEmin" VALUE 0x80284000 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_HSFEsig_C "DFC / OBD specific diagnostic trouble code for check DFC_HSFEsig" VALUE 0x80284002 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_HSHE2max_C "DFC / OBD specific diagnostic trouble code for check DFC_HSHE2max" VALUE 0x80284004 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_HSHE2min_C "DFC / OBD specific diagnostic trouble code for check DFC_HSHE2min" VALUE 0x80284006 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_HSHE2sig_C "DFC / OBD specific diagnostic trouble code for check DFC_HSHE2sig" VALUE 0x80284008 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_HSHEmax_C "DFC / OBD specific diagnostic trouble code for check DFC_HSHEmax" VALUE 0x8028400A Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_HSHEmin_C "DFC / OBD specific diagnostic trouble code for check DFC_HSHEmin" VALUE 0x8028400C Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_HSHEsig_C "DFC / OBD specific diagnostic trouble code for check DFC_HSHEsig" VALUE 0x8028400E Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_HSVE2max_C "DFC / OBD specific diagnostic trouble code for check DFC_HSVE2max" VALUE 0x80284010 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_HSVE2maxLSF_C "DFC / OBD specific diagnostic trouble code for check DFC_HSVE2maxLSF" VALUE 0x80284012 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_HSVE2min_C "DFC / OBD specific diagnostic trouble code for check DFC_HSVE2min" VALUE 0x80284014 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_HSVE2minLSF_C "DFC / OBD specific diagnostic trouble code for check DFC_HSVE2minLSF" VALUE 0x80284016 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_HSVE2sig_C "DFC / OBD specific diagnostic trouble code for check DFC_HSVE2sig" VALUE 0x80284018 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_HSVE2sigLSF_C "DFC / OBD specific diagnostic trouble code for check DFC_HSVE2sigLSF" VALUE 0x8028401A Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_HSVEmax_C "DFC / OBD specific diagnostic trouble code for check DFC_HSVEmax" VALUE 0x8028401C Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_HSVEmaxLSF_C "DFC / OBD specific diagnostic trouble code for check DFC_HSVEmaxLSF" VALUE 0x8028401E Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_HSVEmin_C "DFC / OBD specific diagnostic trouble code for check DFC_HSVEmin" VALUE 0x80284020 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_HSVEminLSF_C "DFC / OBD specific diagnostic trouble code for check DFC_HSVEminLSF" VALUE 0x80284022 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_HSVEsig_C "DFC / OBD specific diagnostic trouble code for check DFC_HSVEsig" VALUE 0x80284024 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_HSVEsigLSF_C "DFC / OBD specific diagnostic trouble code for check DFC_HSVEsigLSF" VALUE 0x80284026 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_ICLSU2max_C "DFC / OBD specific diagnostic trouble code for check DFC_ICLSU2max" VALUE 0x80284028 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_ICLSU2min_C "DFC / OBD specific diagnostic trouble code for check DFC_ICLSU2min" VALUE 0x8028402A Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_ICLSU2npl_C "DFC / OBD specific diagnostic trouble code for check DFC_ICLSU2npl" VALUE 0x8028402C Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_ICLSU2sig_C "DFC / OBD specific diagnostic trouble code for check DFC_ICLSU2sig" VALUE 0x8028402E Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_ICLSUmax_C "DFC / OBD specific diagnostic trouble code for check DFC_ICLSUmax" VALUE 0x80284030 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_ICLSUmin_C "DFC / OBD specific diagnostic trouble code for check DFC_ICLSUmin" VALUE 0x80284032 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_ICLSUnpl_C "DFC / OBD specific diagnostic trouble code for check DFC_ICLSUnpl" VALUE 0x80284034 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_ICLSUsig_C "DFC / OBD specific diagnostic trouble code for check DFC_ICLSUsig" VALUE 0x80284036 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_LSF2max_C "DFC / OBD specific diagnostic trouble code for check DFC_LSF2max" VALUE 0x80284038 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_LSF2min_C "DFC / OBD specific diagnostic trouble code for check DFC_LSF2min" VALUE 0x8028403A Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_LSF2npl_C "DFC / OBD specific diagnostic trouble code for check DFC_LSF2npl" VALUE 0x8028403C Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_LSF2sig_C "DFC / OBD specific diagnostic trouble code for check DFC_LSF2sig" VALUE 0x8028403E Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_LSFmax_C "DFC / OBD specific diagnostic trouble code for check DFC_LSFmax" VALUE 0x80284040 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_LSFmin_C "DFC / OBD specific diagnostic trouble code for check DFC_LSFmin" VALUE 0x80284042 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_LSFnpl_C "DFC / OBD specific diagnostic trouble code for check DFC_LSFnpl" VALUE 0x80284044 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_LSFsig_C "DFC / OBD specific diagnostic trouble code for check DFC_LSFsig" VALUE 0x80284046 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_LSH2max_C "DFC / OBD specific diagnostic trouble code for check DFC_LSH2max" VALUE 0x80284048 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_LSH2min_C "DFC / OBD specific diagnostic trouble code for check DFC_LSH2min" VALUE 0x8028404A Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_LSH2npl_C "DFC / OBD specific diagnostic trouble code for check DFC_LSH2npl" VALUE 0x8028404C Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_LSH2sig_C "DFC / OBD specific diagnostic trouble code for check DFC_LSH2sig" VALUE 0x8028404E Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_LSHmax_C "DFC / OBD specific diagnostic trouble code for check DFC_LSHmax" VALUE 0x80284050 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_LSHmin_C "DFC / OBD specific diagnostic trouble code for check DFC_LSHmin" VALUE 0x80284052 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_LSHnpl_C "DFC / OBD specific diagnostic trouble code for check DFC_LSHnpl" VALUE 0x80284054 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_LSHsig_C "DFC / OBD specific diagnostic trouble code for check DFC_LSHsig" VALUE 0x80284056 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_LSUIA2sig_C "DFC / OBD specific diagnostic trouble code for check DFC_LSUIA2sig" VALUE 0x80284058 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_LSUIAsig_C "DFC / OBD specific diagnostic trouble code for check DFC_LSUIAsig" VALUE 0x8028405A Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_LSUIP2max_C "DFC / OBD specific diagnostic trouble code for check DFC_LSUIP2max" VALUE 0x8028405C Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_LSUIP2npl_C "DFC / OBD specific diagnostic trouble code for check DFC_LSUIP2npl" VALUE 0x8028405E Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_LSUIP2sig_C "DFC / OBD specific diagnostic trouble code for check DFC_LSUIP2sig" VALUE 0x80284060 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_LSUIPmax_C "DFC / OBD specific diagnostic trouble code for check DFC_LSUIPmax" VALUE 0x80284062 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_LSUIPnpl_C "DFC / OBD specific diagnostic trouble code for check DFC_LSUIPnpl" VALUE 0x80284064 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_LSUIPsig_C "DFC / OBD specific diagnostic trouble code for check DFC_LSUIPsig" VALUE 0x80284066 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_LSUKS2max_C "DFC / OBD specific diagnostic trouble code for check DFC_LSUKS2max" VALUE 0x80284068 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_LSUKS2min_C "DFC / OBD specific diagnostic trouble code for check DFC_LSUKS2min" VALUE 0x8028406A Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_LSUKSmax_C "DFC / OBD specific diagnostic trouble code for check DFC_LSUKSmax" VALUE 0x8028406C Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_LSUKSmin_C "DFC / OBD specific diagnostic trouble code for check DFC_LSUKSmin" VALUE 0x8028406E Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_LSUUN2sig_C "DFC / OBD specific diagnostic trouble code for check DFC_LSUUN2sig" VALUE 0x80284070 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_LSUUNsig_C "DFC / OBD specific diagnostic trouble code for check DFC_LSUUNsig" VALUE 0x80284072 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_LSUVM2sig_C "DFC / OBD specific diagnostic trouble code for check DFC_LSUVM2sig" VALUE 0x80284074 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_LSUVMsig_C "DFC / OBD specific diagnostic trouble code for check DFC_LSUVMsig" VALUE 0x80284076 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_LSV2max_C "DFC / OBD specific diagnostic trouble code for check DFC_LSV2max" VALUE 0x80284078 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_LSV2min_C "DFC / OBD specific diagnostic trouble code for check DFC_LSV2min" VALUE 0x8028407A Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_LSV2npl_C "DFC / OBD specific diagnostic trouble code for check DFC_LSV2npl" VALUE 0x8028407C Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_LSV2sig_C "DFC / OBD specific diagnostic trouble code for check DFC_LSV2sig" VALUE 0x8028407E Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_LSVmax_C "DFC / OBD specific diagnostic trouble code for check DFC_LSVmax" VALUE 0x80284080 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_LSVmin_C "DFC / OBD specific diagnostic trouble code for check DFC_LSVmin" VALUE 0x80284082 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_LSVnpl_C "DFC / OBD specific diagnostic trouble code for check DFC_LSVnpl" VALUE 0x80284084 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_LSVsig_C "DFC / OBD specific diagnostic trouble code for check DFC_LSVsig" VALUE 0x80284086 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_MD00max_C "DFC / OBD specific diagnostic trouble code for check DFC_MD00max" VALUE 0x80284088 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_MD00min_C "DFC / OBD specific diagnostic trouble code for check DFC_MD00min" VALUE 0x8028408A Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_MD00npl_C "DFC / OBD specific diagnostic trouble code for check DFC_MD00npl" VALUE 0x8028408C Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_MD01max_C "DFC / OBD specific diagnostic trouble code for check DFC_MD01max" VALUE 0x8028408E Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_MD01min_C "DFC / OBD specific diagnostic trouble code for check DFC_MD01min" VALUE 0x80284090 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_MD01npl_C "DFC / OBD specific diagnostic trouble code for check DFC_MD01npl" VALUE 0x80284092 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_MD02max_C "DFC / OBD specific diagnostic trouble code for check DFC_MD02max" VALUE 0x80284094 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_MD02min_C "DFC / OBD specific diagnostic trouble code for check DFC_MD02min" VALUE 0x80284096 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_MD02npl_C "DFC / OBD specific diagnostic trouble code for check DFC_MD02npl" VALUE 0x80284098 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_MD03max_C "DFC / OBD specific diagnostic trouble code for check DFC_MD03max" VALUE 0x8028409A Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_MD03min_C "DFC / OBD specific diagnostic trouble code for check DFC_MD03min" VALUE 0x8028409C Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_MD03npl_C "DFC / OBD specific diagnostic trouble code for check DFC_MD03npl" VALUE 0x8028409E Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_MD04max_C "DFC / OBD specific diagnostic trouble code for check DFC_MD04max" VALUE 0x802840A0 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_MD04min_C "DFC / OBD specific diagnostic trouble code for check DFC_MD04min" VALUE 0x802840A2 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_MD04npl_C "DFC / OBD specific diagnostic trouble code for check DFC_MD04npl" VALUE 0x802840A4 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_MD05max_C "DFC / OBD specific diagnostic trouble code for check DFC_MD05max" VALUE 0x802840A6 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_MD05min_C "DFC / OBD specific diagnostic trouble code for check DFC_MD05min" VALUE 0x802840A8 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_MD05npl_C "DFC / OBD specific diagnostic trouble code for check DFC_MD05npl" VALUE 0x802840AA Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_MD06max_C "DFC / OBD specific diagnostic trouble code for check DFC_MD06max" VALUE 0x802840AC Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_MD06min_C "DFC / OBD specific diagnostic trouble code for check DFC_MD06min" VALUE 0x802840AE Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_MD06npl_C "DFC / OBD specific diagnostic trouble code for check DFC_MD06npl" VALUE 0x802840B0 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_MD07max_C "DFC / OBD specific diagnostic trouble code for check DFC_MD07max" VALUE 0x802840B2 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_MD07min_C "DFC / OBD specific diagnostic trouble code for check DFC_MD07min" VALUE 0x802840B4 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_MD07npl_C "DFC / OBD specific diagnostic trouble code for check DFC_MD07npl" VALUE 0x802840B6 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_MDmax_C "DFC / OBD specific diagnostic trouble code for check DFC_MDmax" VALUE 0x802840B8 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_MDmin_C "DFC / OBD specific diagnostic trouble code for check DFC_MDmin" VALUE 0x802840BA Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_MDnpl_C "DFC / OBD specific diagnostic trouble code for check DFC_MDnpl" VALUE 0x802840BC Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_MRlyErlyOpng_C "DFC / OBD specific diagnostic trouble code for check DFC_MRlyErlyOpng" VALUE 0x802840BE Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_MRlyStk_C "DFC / OBD specific diagnostic trouble code for check DFC_MRlyStk" VALUE 0x802840C0 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_PLLSUmax_C "DFC / OBD specific diagnostic trouble code for check DFC_PLLSUmax" VALUE 0x802840C2 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_PLLSUmin_C "DFC / OBD specific diagnostic trouble code for check DFC_PLLSUmin" VALUE 0x802840C4 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_PLLSUnpl_C "DFC / OBD specific diagnostic trouble code for check DFC_PLLSUnpl" VALUE 0x802840C6 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_PLLSUsig_C "DFC / OBD specific diagnostic trouble code for check DFC_PLLSUsig" VALUE 0x802840C8 Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_SWReset_0_C "DFC / OBD specific diagnostic trouble code for check DFC_SWReset_0" VALUE 0x802840CA Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_SWReset_1_C "DFC / OBD specific diagnostic trouble code for check DFC_SWReset_1" VALUE 0x802840CC Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_DTCO.DFC_SWReset_2_C "DFC / OBD specific diagnostic trouble code for check DFC_SWReset_2" VALUE 0x802840CE Val_Wu16 65535.00 DFES_OneToOne 0.00 65535.00 FORMAT "%8.2" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_Env.xSet1_CA "DFES / Signal selection for environment dataset 1" VAL_BLK 0x8028427E ValA_Wu16 36.0000000000 Signals_IntSigNumVerb 0.00 36.0000000000 FORMAT "%13.10" NUMBER 2 /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_Env.xSet2_CA "DFES / Signal selection for environment dataset 2" VAL_BLK 0x80284282 ValA_Wu16 36.0000000000 Signals_IntSigNumVerb 0.00 36.0000000000 FORMAT "%13.10" NUMBER 2 /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_Env.xSet3_CA "DFES / Signal selection for environment dataset 3" VAL_BLK 0x80284286 ValA_Wu16 36.0000000000 Signals_IntSigNumVerb 0.00 36.0000000000 FORMAT "%13.10" NUMBER 2 /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_Env.xSet4_CA "DFES / Signal selection for environment dataset 4" VAL_BLK 0x8028428A ValA_Wu16 36.0000000000 Signals_IntSigNumVerb 0.00 36.0000000000 FORMAT "%13.10" NUMBER 2 /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_Env.xSet5_CA "DFES / Signal selection for environment dataset 5" VAL_BLK 0x8028428E ValA_Wu16 36.0000000000 Signals_IntSigNumVerb 0.00 36.0000000000 FORMAT "%13.10" NUMBER 2 /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_Env.xSet6_CA "DFES / Signal selection for environment dataset 6" VAL_BLK 0x80284292 ValA_Wu16 36.0000000000 Signals_IntSigNumVerb 0.00 36.0000000000 FORMAT "%13.10" NUMBER 2 /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_Env.xSet7_CA "DFES / Signal selection for environment dataset 7" VAL_BLK 0x80284296 ValA_Wu16 36.0000000000 Signals_IntSigNumVerb 0.00 36.0000000000 FORMAT "%13.10" NUMBER 2 /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_Env.xSet8_CA "DFES / Signal selection for environment dataset 8" VAL_BLK 0x8028429A ValA_Wu16 36.0000000000 Signals_IntSigNumVerb 0.00 36.0000000000 FORMAT "%13.10" NUMBER 2 /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_Env.xSet9_CA "DFES / Signal selection for environment dataset 9" VAL_BLK 0x8028429E ValA_Wu16 36.0000000000 Signals_IntSigNumVerb 0.00 36.0000000000 FORMAT "%13.10" NUMBER 2 /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_Env.xSet10_CA "DFES / Signal selection for environment dataset 10" VAL_BLK 0x802842A2 ValA_Wu16 36.0000000000 Signals_IntSigNumVerb 0.00 36.0000000000 FORMAT "%13.10" NUMBER 2 /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_Env.xSet11_CA "DFES / Signal selection for environment dataset 11" VAL_BLK 0x802842A6 ValA_Wu16 36.0000000000 Signals_IntSigNumVerb 0.00 36.0000000000 FORMAT "%13.10" NUMBER 2 /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_Env.xSet12_CA "DFES / Signal selection for environment dataset 12" VAL_BLK 0x802842AA ValA_Wu16 36.0000000000 Signals_IntSigNumVerb 0.00 36.0000000000 FORMAT "%13.10" NUMBER 2 /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_Env.xSet13_CA "DFES / Signal selection for environment dataset 13" VAL_BLK 0x802842AE ValA_Wu16 36.0000000000 Signals_IntSigNumVerb 0.00 36.0000000000 FORMAT "%13.10" NUMBER 2 /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_Env.xSet14_CA "DFES / Signal selection for environment dataset 14" VAL_BLK 0x802842B2 ValA_Wu16 36.0000000000 Signals_IntSigNumVerb 0.00 36.0000000000 FORMAT "%13.10" NUMBER 2 /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_Env.xSet15_CA "DFES / Signal selection for environment dataset 15" VAL_BLK 0x802842B6 ValA_Wu16 36.0000000000 Signals_IntSigNumVerb 0.00 36.0000000000 FORMAT "%13.10" NUMBER 2 /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_Env.xSet16_CA "DFES / Signal selection for environment dataset 16" VAL_BLK 0x802842BA ValA_Wu16 36.0000000000 Signals_IntSigNumVerb 0.00 36.0000000000 FORMAT "%13.10" NUMBER 2 /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_Env.xSet17_CA "DFES / Signal selection for environment dataset 17" VAL_BLK 0x802842BE ValA_Wu16 36.0000000000 Signals_IntSigNumVerb 0.00 36.0000000000 FORMAT "%13.10" NUMBER 2 /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_Env.xSet18_CA "DFES / Signal selection for environment dataset 18" VAL_BLK 0x802842C2 ValA_Wu16 36.0000000000 Signals_IntSigNumVerb 0.00 36.0000000000 FORMAT "%13.10" NUMBER 2 /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_Env.xSet19_CA "DFES / Signal selection for environment dataset 19" VAL_BLK 0x802842C6 ValA_Wu16 36.0000000000 Signals_IntSigNumVerb 0.00 36.0000000000 FORMAT "%13.10" NUMBER 2 /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_Env.xSet20_CA "DFES / Signal selection for environment dataset 20" VAL_BLK 0x802842CA ValA_Wu16 36.0000000000 Signals_IntSigNumVerb 0.00 36.0000000000 FORMAT "%13.10" NUMBER 2 /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_Env.xSet21_CA "DFES / Signal selection for environment dataset 21" VAL_BLK 0x802842CE ValA_Wu16 36.0000000000 Signals_IntSigNumVerb 0.00 36.0000000000 FORMAT "%13.10" NUMBER 2 /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_Env.xSet22_CA "DFES / Signal selection for environment dataset 22" VAL_BLK 0x802842D2 ValA_Wu16 36.0000000000 Signals_IntSigNumVerb 0.00 36.0000000000 FORMAT "%13.10" NUMBER 2 /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_Env.xSet23_CA "DFES / Signal selection for environment dataset 23" VAL_BLK 0x802842D6 ValA_Wu16 36.0000000000 Signals_IntSigNumVerb 0.00 36.0000000000 FORMAT "%13.10" NUMBER 2 /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_Env.xSet24_CA "DFES / Signal selection for environment dataset 24" VAL_BLK 0x802842DA ValA_Wu16 36.0000000000 Signals_IntSigNumVerb 0.00 36.0000000000 FORMAT "%13.10" NUMBER 2 /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_Env.xSet25_CA "DFES / Signal selection for environment dataset 25" VAL_BLK 0x802842DE ValA_Wu16 36.0000000000 Signals_IntSigNumVerb 0.00 36.0000000000 FORMAT "%13.10" NUMBER 2 /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_Env.xSet26_CA "DFES / Signal selection for environment dataset 26" VAL_BLK 0x802842E2 ValA_Wu16 36.0000000000 Signals_IntSigNumVerb 0.00 36.0000000000 FORMAT "%13.10" NUMBER 2 /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_Env.xSet27_CA "DFES / Signal selection for environment dataset 27" VAL_BLK 0x802842E6 ValA_Wu16 36.0000000000 Signals_IntSigNumVerb 0.00 36.0000000000 FORMAT "%13.10" NUMBER 2 /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_Env.xSet28_CA "DFES / Signal selection for environment dataset 28" VAL_BLK 0x802842EA ValA_Wu16 36.0000000000 Signals_IntSigNumVerb 0.00 36.0000000000 FORMAT "%13.10" NUMBER 2 /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_Env.xSet29_CA "DFES / Signal selection for environment dataset 29" VAL_BLK 0x802842EE ValA_Wu16 36.0000000000 Signals_IntSigNumVerb 0.00 36.0000000000 FORMAT "%13.10" NUMBER 2 /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_Env.xSet30_CA "DFES / Signal selection for environment dataset 30" VAL_BLK 0x802842F2 ValA_Wu16 36.0000000000 Signals_IntSigNumVerb 0.00 36.0000000000 FORMAT "%13.10" NUMBER 2 /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_Env.xSet31_CA "DFES / Signal selection for environment dataset 31" VAL_BLK 0x802842F6 ValA_Wu16 36.0000000000 Signals_IntSigNumVerb 0.00 36.0000000000 FORMAT "%13.10" NUMBER 2 /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_Env.xSet32_CA "DFES / Signal selection for environment dataset 32" VAL_BLK 0x802842FA ValA_Wu16 36.0000000000 Signals_IntSigNumVerb 0.00 36.0000000000 FORMAT "%13.10" NUMBER 2 /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_Env.xSet33_CA "DFES / Signal selection for environment dataset 33" VAL_BLK 0x802842FE ValA_Wu16 36.0000000000 Signals_IntSigNumVerb 0.00 36.0000000000 FORMAT "%13.10" NUMBER 2 /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_Env.xSet34_CA "DFES / Signal selection for environment dataset 34" VAL_BLK 0x80284302 ValA_Wu16 36.0000000000 Signals_IntSigNumVerb 0.00 36.0000000000 FORMAT "%13.10" NUMBER 2 /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_Env.xSet35_CA "DFES / Signal selection for environment dataset 35" VAL_BLK 0x80284306 ValA_Wu16 36.0000000000 Signals_IntSigNumVerb 0.00 36.0000000000 FORMAT "%13.10" NUMBER 2 /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_Env.xSet36_CA "DFES / Signal selection for environment dataset 36" VAL_BLK 0x8028430A ValA_Wu16 36.0000000000 Signals_IntSigNumVerb 0.00 36.0000000000 FORMAT "%13.10" NUMBER 2 /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_Env.xSet37_CA "DFES / Signal selection for environment dataset 37" VAL_BLK 0x8028430E ValA_Wu16 36.0000000000 Signals_IntSigNumVerb 0.00 36.0000000000 FORMAT "%13.10" NUMBER 2 /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_Env.xSet38_CA "DFES / Signal selection for environment dataset 38" VAL_BLK 0x80284312 ValA_Wu16 36.0000000000 Signals_IntSigNumVerb 0.00 36.0000000000 FORMAT "%13.10" NUMBER 2 /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_Env.xSet39_CA "DFES / Signal selection for environment dataset 39" VAL_BLK 0x80284316 ValA_Wu16 36.0000000000 Signals_IntSigNumVerb 0.00 36.0000000000 FORMAT "%13.10" NUMBER 2 /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_Env.xSet40_CA "DFES / Signal selection for environment dataset 40" VAL_BLK 0x8028431A ValA_Wu16 36.0000000000 Signals_IntSigNumVerb 0.00 36.0000000000 FORMAT "%13.10" NUMBER 2 /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_Env.xSet41_CA "DFES / Signal selection for environment dataset 41" VAL_BLK 0x8028431E ValA_Wu16 36.0000000000 Signals_IntSigNumVerb 0.00 36.0000000000 FORMAT "%13.10" NUMBER 2 /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_Env.xSet42_CA "DFES / Signal selection for environment dataset 42" VAL_BLK 0x80284322 ValA_Wu16 36.0000000000 Signals_IntSigNumVerb 0.00 36.0000000000 FORMAT "%13.10" NUMBER 2 /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_Env.xSet43_CA "DFES / Signal selection for environment dataset 43" VAL_BLK 0x80284326 ValA_Wu16 36.0000000000 Signals_IntSigNumVerb 0.00 36.0000000000 FORMAT "%13.10" NUMBER 2 /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_Env.xSet44_CA "DFES / Signal selection for environment dataset 44" VAL_BLK 0x8028432A ValA_Wu16 36.0000000000 Signals_IntSigNumVerb 0.00 36.0000000000 FORMAT "%13.10" NUMBER 2 /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_Env.xSet45_CA "DFES / Signal selection for environment dataset 45" VAL_BLK 0x8028432E ValA_Wu16 36.0000000000 Signals_IntSigNumVerb 0.00 36.0000000000 FORMAT "%13.10" NUMBER 2 /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_Env.xSet46_CA "DFES / Signal selection for environment dataset 46" VAL_BLK 0x80284332 ValA_Wu16 36.0000000000 Signals_IntSigNumVerb 0.00 36.0000000000 FORMAT "%13.10" NUMBER 2 /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_Env.xSet47_CA "DFES / Signal selection for environment dataset 47" VAL_BLK 0x80284336 ValA_Wu16 36.0000000000 Signals_IntSigNumVerb 0.00 36.0000000000 FORMAT "%13.10" NUMBER 2 /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_Env.xSet48_CA "DFES / Signal selection for environment dataset 48" VAL_BLK 0x8028433A ValA_Wu16 36.0000000000 Signals_IntSigNumVerb 0.00 36.0000000000 FORMAT "%13.10" NUMBER 2 /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_Env.xSet49_CA "DFES / Signal selection for environment dataset 49" VAL_BLK 0x8028433E ValA_Wu16 36.0000000000 Signals_IntSigNumVerb 0.00 36.0000000000 FORMAT "%13.10" NUMBER 2 /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_Env.xSet50_CA "DFES / Signal selection for environment dataset 50" VAL_BLK 0x80284342 ValA_Wu16 36.0000000000 Signals_IntSigNumVerb 0.00 36.0000000000 FORMAT "%13.10" NUMBER 2 /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_Unused_C "DFC / " VALUE 0x802840D4 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" READ_ONLY /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_BusDiagBusOffErrPasNodeA_C "DFC / Reference of environment condition set for check DFC_BusDiagBusOffErrPasNodeA" VALUE 0x802840D5 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_BusDiagBusOffErrPasNodeB_C "DFC / Reference of environment condition set for check DFC_BusDiagBusOffErrPasNodeB" VALUE 0x802840D6 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_BusDiagBusOffErrPasNodeC_C "DFC / Reference of environment condition set for check DFC_BusDiagBusOffErrPasNodeC" VALUE 0x802840D7 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_BusDiagBusOffErrPasNodeD_C "DFC / Reference of environment condition set for check DFC_BusDiagBusOffErrPasNodeD" VALUE 0x802840D8 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_BusDiagBusOffNodeA_C "DFC / Reference of environment condition set for check DFC_BusDiagBusOffNodeA" VALUE 0x802840D9 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_BusDiagBusOffNodeB_C "DFC / Reference of environment condition set for check DFC_BusDiagBusOffNodeB" VALUE 0x802840DA Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_BusDiagBusOffNodeC_C "DFC / Reference of environment condition set for check DFC_BusDiagBusOffNodeC" VALUE 0x802840DB Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_BusDiagBusOffNodeD_C "DFC / Reference of environment condition set for check DFC_BusDiagBusOffNodeD" VALUE 0x802840DC Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_ComCANG1_HDL0TO_C "DFC / Reference of environment condition set for check DFC_ComCANG1_HDL0TO" VALUE 0x802840DD Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_ComCANG1_HDL10TO_C "DFC / Reference of environment condition set for check DFC_ComCANG1_HDL10TO" VALUE 0x802840DE Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_ComCANG1_HDL11TO_C "DFC / Reference of environment condition set for check DFC_ComCANG1_HDL11TO" VALUE 0x802840DF Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_ComCANG1_HDL12TO_C "DFC / Reference of environment condition set for check DFC_ComCANG1_HDL12TO" VALUE 0x802840E0 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_ComCANG1_HDL13TO_C "DFC / Reference of environment condition set for check DFC_ComCANG1_HDL13TO" VALUE 0x802840E1 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_ComCANG1_HDL14TO_C "DFC / Reference of environment condition set for check DFC_ComCANG1_HDL14TO" VALUE 0x802840E2 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_ComCANG1_HDL15TO_C "DFC / Reference of environment condition set for check DFC_ComCANG1_HDL15TO" VALUE 0x802840E3 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_ComCANG1_HDL16TO_C "DFC / Reference of environment condition set for check DFC_ComCANG1_HDL16TO" VALUE 0x802840E4 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_ComCANG1_HDL17TO_C "DFC / Reference of environment condition set for check DFC_ComCANG1_HDL17TO" VALUE 0x802840E5 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_ComCANG1_HDL18TO_C "DFC / Reference of environment condition set for check DFC_ComCANG1_HDL18TO" VALUE 0x802840E6 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_ComCANG1_HDL19TO_C "DFC / Reference of environment condition set for check DFC_ComCANG1_HDL19TO" VALUE 0x802840E7 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_ComCANG1_HDL1TO_C "DFC / Reference of environment condition set for check DFC_ComCANG1_HDL1TO" VALUE 0x802840E8 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_ComCANG1_HDL20TO_C "DFC / Reference of environment condition set for check DFC_ComCANG1_HDL20TO" VALUE 0x802840E9 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_ComCANG1_HDL21TO_C "DFC / Reference of environment condition set for check DFC_ComCANG1_HDL21TO" VALUE 0x802840EA Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_ComCANG1_HDL22TO_C "DFC / Reference of environment condition set for check DFC_ComCANG1_HDL22TO" VALUE 0x802840EB Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_ComCANG1_HDL23TO_C "DFC / Reference of environment condition set for check DFC_ComCANG1_HDL23TO" VALUE 0x802840EC Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_ComCANG1_HDL24TO_C "DFC / Reference of environment condition set for check DFC_ComCANG1_HDL24TO" VALUE 0x802840ED Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_ComCANG1_HDL2TO_C "DFC / Reference of environment condition set for check DFC_ComCANG1_HDL2TO" VALUE 0x802840EE Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_ComCANG1_HDL3TO_C "DFC / Reference of environment condition set for check DFC_ComCANG1_HDL3TO" VALUE 0x802840EF Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_ComCANG1_HDL4TO_C "DFC / Reference of environment condition set for check DFC_ComCANG1_HDL4TO" VALUE 0x802840F0 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_ComCANG1_HDL5TO_C "DFC / Reference of environment condition set for check DFC_ComCANG1_HDL5TO" VALUE 0x802840F1 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_ComCANG1_HDL6TO_C "DFC / Reference of environment condition set for check DFC_ComCANG1_HDL6TO" VALUE 0x802840F2 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_ComCANG1_HDL7TO_C "DFC / Reference of environment condition set for check DFC_ComCANG1_HDL7TO" VALUE 0x802840F3 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_ComCANG1_HDL8TO_C "DFC / Reference of environment condition set for check DFC_ComCANG1_HDL8TO" VALUE 0x802840F4 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_ComCANG1_HDL9TO_C "DFC / Reference of environment condition set for check DFC_ComCANG1_HDL9TO" VALUE 0x802840F5 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_ComCANG2_HDL0TO_C "DFC / Reference of environment condition set for check DFC_ComCANG2_HDL0TO" VALUE 0x802840F6 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_ComCANG2_HDL10TO_C "DFC / Reference of environment condition set for check DFC_ComCANG2_HDL10TO" VALUE 0x802840F7 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_ComCANG2_HDL11TO_C "DFC / Reference of environment condition set for check DFC_ComCANG2_HDL11TO" VALUE 0x802840F8 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_ComCANG2_HDL12TO_C "DFC / Reference of environment condition set for check DFC_ComCANG2_HDL12TO" VALUE 0x802840F9 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_ComCANG2_HDL13TO_C "DFC / Reference of environment condition set for check DFC_ComCANG2_HDL13TO" VALUE 0x802840FA Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_ComCANG2_HDL14TO_C "DFC / Reference of environment condition set for check DFC_ComCANG2_HDL14TO" VALUE 0x802840FB Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_ComCANG2_HDL15TO_C "DFC / Reference of environment condition set for check DFC_ComCANG2_HDL15TO" VALUE 0x802840FC Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_ComCANG2_HDL16TO_C "DFC / Reference of environment condition set for check DFC_ComCANG2_HDL16TO" VALUE 0x802840FD Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_ComCANG2_HDL17TO_C "DFC / Reference of environment condition set for check DFC_ComCANG2_HDL17TO" VALUE 0x802840FE Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_ComCANG2_HDL18TO_C "DFC / Reference of environment condition set for check DFC_ComCANG2_HDL18TO" VALUE 0x802840FF Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_ComCANG2_HDL19TO_C "DFC / Reference of environment condition set for check DFC_ComCANG2_HDL19TO" VALUE 0x80284100 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_ComCANG2_HDL1TO_C "DFC / Reference of environment condition set for check DFC_ComCANG2_HDL1TO" VALUE 0x80284101 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_ComCANG2_HDL20TO_C "DFC / Reference of environment condition set for check DFC_ComCANG2_HDL20TO" VALUE 0x80284102 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_ComCANG2_HDL21TO_C "DFC / Reference of environment condition set for check DFC_ComCANG2_HDL21TO" VALUE 0x80284103 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_ComCANG2_HDL22TO_C "DFC / Reference of environment condition set for check DFC_ComCANG2_HDL22TO" VALUE 0x80284104 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_ComCANG2_HDL23TO_C "DFC / Reference of environment condition set for check DFC_ComCANG2_HDL23TO" VALUE 0x80284105 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_ComCANG2_HDL24TO_C "DFC / Reference of environment condition set for check DFC_ComCANG2_HDL24TO" VALUE 0x80284106 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_ComCANG2_HDL2TO_C "DFC / Reference of environment condition set for check DFC_ComCANG2_HDL2TO" VALUE 0x80284107 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_ComCANG2_HDL3TO_C "DFC / Reference of environment condition set for check DFC_ComCANG2_HDL3TO" VALUE 0x80284108 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_ComCANG2_HDL4TO_C "DFC / Reference of environment condition set for check DFC_ComCANG2_HDL4TO" VALUE 0x80284109 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_ComCANG2_HDL5TO_C "DFC / Reference of environment condition set for check DFC_ComCANG2_HDL5TO" VALUE 0x8028410A Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_ComCANG2_HDL6TO_C "DFC / Reference of environment condition set for check DFC_ComCANG2_HDL6TO" VALUE 0x8028410B Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_ComCANG2_HDL7TO_C "DFC / Reference of environment condition set for check DFC_ComCANG2_HDL7TO" VALUE 0x8028410C Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_ComCANG2_HDL8TO_C "DFC / Reference of environment condition set for check DFC_ComCANG2_HDL8TO" VALUE 0x8028410D Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_ComCANG2_HDL9TO_C "DFC / Reference of environment condition set for check DFC_ComCANG2_HDL9TO" VALUE 0x8028410E Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_ComCANG3_HDL0TO_C "DFC / Reference of environment condition set for check DFC_ComCANG3_HDL0TO" VALUE 0x8028410F Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_ComCANG3_HDL10TO_C "DFC / Reference of environment condition set for check DFC_ComCANG3_HDL10TO" VALUE 0x80284110 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_ComCANG3_HDL11TO_C "DFC / Reference of environment condition set for check DFC_ComCANG3_HDL11TO" VALUE 0x80284111 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_ComCANG3_HDL12TO_C "DFC / Reference of environment condition set for check DFC_ComCANG3_HDL12TO" VALUE 0x80284112 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_ComCANG3_HDL13TO_C "DFC / Reference of environment condition set for check DFC_ComCANG3_HDL13TO" VALUE 0x80284113 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_ComCANG3_HDL14TO_C "DFC / Reference of environment condition set for check DFC_ComCANG3_HDL14TO" VALUE 0x80284114 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_ComCANG3_HDL15TO_C "DFC / Reference of environment condition set for check DFC_ComCANG3_HDL15TO" VALUE 0x80284115 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_ComCANG3_HDL16TO_C "DFC / Reference of environment condition set for check DFC_ComCANG3_HDL16TO" VALUE 0x80284116 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_ComCANG3_HDL17TO_C "DFC / Reference of environment condition set for check DFC_ComCANG3_HDL17TO" VALUE 0x80284117 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_ComCANG3_HDL18TO_C "DFC / Reference of environment condition set for check DFC_ComCANG3_HDL18TO" VALUE 0x80284118 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_ComCANG3_HDL19TO_C "DFC / Reference of environment condition set for check DFC_ComCANG3_HDL19TO" VALUE 0x80284119 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_ComCANG3_HDL1TO_C "DFC / Reference of environment condition set for check DFC_ComCANG3_HDL1TO" VALUE 0x8028411A Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_ComCANG3_HDL20TO_C "DFC / Reference of environment condition set for check DFC_ComCANG3_HDL20TO" VALUE 0x8028411B Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_ComCANG3_HDL21TO_C "DFC / Reference of environment condition set for check DFC_ComCANG3_HDL21TO" VALUE 0x8028411C Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_ComCANG3_HDL22TO_C "DFC / Reference of environment condition set for check DFC_ComCANG3_HDL22TO" VALUE 0x8028411D Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_ComCANG3_HDL23TO_C "DFC / Reference of environment condition set for check DFC_ComCANG3_HDL23TO" VALUE 0x8028411E Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_ComCANG3_HDL24TO_C "DFC / Reference of environment condition set for check DFC_ComCANG3_HDL24TO" VALUE 0x8028411F Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_ComCANG3_HDL2TO_C "DFC / Reference of environment condition set for check DFC_ComCANG3_HDL2TO" VALUE 0x80284120 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_ComCANG3_HDL3TO_C "DFC / Reference of environment condition set for check DFC_ComCANG3_HDL3TO" VALUE 0x80284121 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_ComCANG3_HDL4TO_C "DFC / Reference of environment condition set for check DFC_ComCANG3_HDL4TO" VALUE 0x80284122 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_ComCANG3_HDL5TO_C "DFC / Reference of environment condition set for check DFC_ComCANG3_HDL5TO" VALUE 0x80284123 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_ComCANG3_HDL6TO_C "DFC / Reference of environment condition set for check DFC_ComCANG3_HDL6TO" VALUE 0x80284124 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_ComCANG3_HDL7TO_C "DFC / Reference of environment condition set for check DFC_ComCANG3_HDL7TO" VALUE 0x80284125 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_ComCANG3_HDL8TO_C "DFC / Reference of environment condition set for check DFC_ComCANG3_HDL8TO" VALUE 0x80284126 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_ComCANG3_HDL9TO_C "DFC / Reference of environment condition set for check DFC_ComCANG3_HDL9TO" VALUE 0x80284127 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_ComCANG4_HDL0TO_C "DFC / Reference of environment condition set for check DFC_ComCANG4_HDL0TO" VALUE 0x80284128 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_ComCANG4_HDL10TO_C "DFC / Reference of environment condition set for check DFC_ComCANG4_HDL10TO" VALUE 0x80284129 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_ComCANG4_HDL11TO_C "DFC / Reference of environment condition set for check DFC_ComCANG4_HDL11TO" VALUE 0x8028412A Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_ComCANG4_HDL12TO_C "DFC / Reference of environment condition set for check DFC_ComCANG4_HDL12TO" VALUE 0x8028412B Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_ComCANG4_HDL13TO_C "DFC / Reference of environment condition set for check DFC_ComCANG4_HDL13TO" VALUE 0x8028412C Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_ComCANG4_HDL14TO_C "DFC / Reference of environment condition set for check DFC_ComCANG4_HDL14TO" VALUE 0x8028412D Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_ComCANG4_HDL15TO_C "DFC / Reference of environment condition set for check DFC_ComCANG4_HDL15TO" VALUE 0x8028412E Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_ComCANG4_HDL16TO_C "DFC / Reference of environment condition set for check DFC_ComCANG4_HDL16TO" VALUE 0x8028412F Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_ComCANG4_HDL17TO_C "DFC / Reference of environment condition set for check DFC_ComCANG4_HDL17TO" VALUE 0x80284130 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_ComCANG4_HDL18TO_C "DFC / Reference of environment condition set for check DFC_ComCANG4_HDL18TO" VALUE 0x80284131 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_ComCANG4_HDL19TO_C "DFC / Reference of environment condition set for check DFC_ComCANG4_HDL19TO" VALUE 0x80284132 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_ComCANG4_HDL1TO_C "DFC / Reference of environment condition set for check DFC_ComCANG4_HDL1TO" VALUE 0x80284133 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_ComCANG4_HDL20TO_C "DFC / Reference of environment condition set for check DFC_ComCANG4_HDL20TO" VALUE 0x80284134 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_ComCANG4_HDL21TO_C "DFC / Reference of environment condition set for check DFC_ComCANG4_HDL21TO" VALUE 0x80284135 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_ComCANG4_HDL22TO_C "DFC / Reference of environment condition set for check DFC_ComCANG4_HDL22TO" VALUE 0x80284136 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_ComCANG4_HDL23TO_C "DFC / Reference of environment condition set for check DFC_ComCANG4_HDL23TO" VALUE 0x80284137 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_ComCANG4_HDL24TO_C "DFC / Reference of environment condition set for check DFC_ComCANG4_HDL24TO" VALUE 0x80284138 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_ComCANG4_HDL2TO_C "DFC / Reference of environment condition set for check DFC_ComCANG4_HDL2TO" VALUE 0x80284139 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_ComCANG4_HDL3TO_C "DFC / Reference of environment condition set for check DFC_ComCANG4_HDL3TO" VALUE 0x8028413A Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_ComCANG4_HDL4TO_C "DFC / Reference of environment condition set for check DFC_ComCANG4_HDL4TO" VALUE 0x8028413B Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_ComCANG4_HDL5TO_C "DFC / Reference of environment condition set for check DFC_ComCANG4_HDL5TO" VALUE 0x8028413C Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_ComCANG4_HDL6TO_C "DFC / Reference of environment condition set for check DFC_ComCANG4_HDL6TO" VALUE 0x8028413D Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_ComCANG4_HDL7TO_C "DFC / Reference of environment condition set for check DFC_ComCANG4_HDL7TO" VALUE 0x8028413E Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_ComCANG4_HDL8TO_C "DFC / Reference of environment condition set for check DFC_ComCANG4_HDL8TO" VALUE 0x8028413F Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_ComCANG4_HDL9TO_C "DFC / Reference of environment condition set for check DFC_ComCANG4_HDL9TO" VALUE 0x80284140 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_Cy150SpiCom_C "DFC / Reference of environment condition set for check DFC_Cy150SpiCom" VALUE 0x80284141 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_Cy320SpiCom_C "DFC / Reference of environment condition set for check DFC_Cy320SpiCom" VALUE 0x80284142 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_MonUMaxSupply1_C "DFC / Reference of environment condition set for check DFC_MonUMaxSupply1" VALUE 0x80284143 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_MonUMaxSupply2_C "DFC / Reference of environment condition set for check DFC_MonUMaxSupply2" VALUE 0x80284144 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_MonUMaxSupply3_C "DFC / Reference of environment condition set for check DFC_MonUMaxSupply3" VALUE 0x80284145 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_MonUMinSupply1_C "DFC / Reference of environment condition set for check DFC_MonUMinSupply1" VALUE 0x80284146 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_MonUMinSupply2_C "DFC / Reference of environment condition set for check DFC_MonUMinSupply2" VALUE 0x80284147 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_MonUMinSupply3_C "DFC / Reference of environment condition set for check DFC_MonUMinSupply3" VALUE 0x80284148 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_SSpMon1_C "DFC / Reference of environment condition set for check DFC_SSpMon1" VALUE 0x80284149 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_SSpMon1OV_C "DFC / Reference of environment condition set for check DFC_SSpMon1OV" VALUE 0x8028414A Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_SSpMon1UV_C "DFC / Reference of environment condition set for check DFC_SSpMon1UV" VALUE 0x8028414B Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_SSpMon2_C "DFC / Reference of environment condition set for check DFC_SSpMon2" VALUE 0x8028414C Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_SSpMon2OV_C "DFC / Reference of environment condition set for check DFC_SSpMon2OV" VALUE 0x8028414D Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_SSpMon2UV_C "DFC / Reference of environment condition set for check DFC_SSpMon2UV" VALUE 0x8028414E Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_SSpMon3_C "DFC / Reference of environment condition set for check DFC_SSpMon3" VALUE 0x8028414F Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_SSpMon3OV_C "DFC / Reference of environment condition set for check DFC_SSpMon3OV" VALUE 0x80284150 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_SSpMon3UV_C "DFC / Reference of environment condition set for check DFC_SSpMon3UV" VALUE 0x80284151 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_HDEVK_MIN_0_C "DFC / Reference of environment condition set for check DFC_HDEVK_MIN_0" VALUE 0x80284152 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_HDEVK_MIN_1_C "DFC / Reference of environment condition set for check DFC_HDEVK_MIN_1" VALUE 0x80284153 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_HDEVK_NPL_0_C "DFC / Reference of environment condition set for check DFC_HDEVK_NPL_0" VALUE 0x80284154 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_HDEVK_NPL_1_C "DFC / Reference of environment condition set for check DFC_HDEVK_NPL_1" VALUE 0x80284155 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_HDEVK_SIG_0_C "DFC / Reference of environment condition set for check DFC_HDEVK_SIG_0" VALUE 0x80284156 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_HDEVK_SIG_1_C "DFC / Reference of environment condition set for check DFC_HDEVK_SIG_1" VALUE 0x80284157 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_IgnClPsClOpen0_C "DFC / Reference of environment condition set for check DFC_IgnClPsClOpen0" VALUE 0x80284158 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_IgnClPsClOpen1_C "DFC / Reference of environment condition set for check DFC_IgnClPsClOpen1" VALUE 0x80284159 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_IgnClPsClOpen2_C "DFC / Reference of environment condition set for check DFC_IgnClPsClOpen2" VALUE 0x8028415A Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_IgnClPsClOpen3_C "DFC / Reference of environment condition set for check DFC_IgnClPsClOpen3" VALUE 0x8028415B Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_IgnClPsClOpen4_C "DFC / Reference of environment condition set for check DFC_IgnClPsClOpen4" VALUE 0x8028415C Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_IgnClPsClOpen5_C "DFC / Reference of environment condition set for check DFC_IgnClPsClOpen5" VALUE 0x8028415D Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_IgnClPsClOpen6_C "DFC / Reference of environment condition set for check DFC_IgnClPsClOpen6" VALUE 0x8028415E Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_IgnClPsClOpen7_C "DFC / Reference of environment condition set for check DFC_IgnClPsClOpen7" VALUE 0x8028415F Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_IgnClPsClShCir0_C "DFC / Reference of environment condition set for check DFC_IgnClPsClShCir0" VALUE 0x80284160 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_IgnClPsClShCir1_C "DFC / Reference of environment condition set for check DFC_IgnClPsClShCir1" VALUE 0x80284161 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_IgnClPsClShCir2_C "DFC / Reference of environment condition set for check DFC_IgnClPsClShCir2" VALUE 0x80284162 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_IgnClPsClShCir3_C "DFC / Reference of environment condition set for check DFC_IgnClPsClShCir3" VALUE 0x80284163 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_IgnClPsClShCir4_C "DFC / Reference of environment condition set for check DFC_IgnClPsClShCir4" VALUE 0x80284164 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_IgnClPsClShCir5_C "DFC / Reference of environment condition set for check DFC_IgnClPsClShCir5" VALUE 0x80284165 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_IgnClPsClShCir6_C "DFC / Reference of environment condition set for check DFC_IgnClPsClShCir6" VALUE 0x80284166 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_IgnClPsClShCir7_C "DFC / Reference of environment condition set for check DFC_IgnClPsClShCir7" VALUE 0x80284167 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_IgnClPsClUnExpt0_C "DFC / Reference of environment condition set for check DFC_IgnClPsClUnExpt0" VALUE 0x80284168 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_IgnClPsClUnExpt1_C "DFC / Reference of environment condition set for check DFC_IgnClPsClUnExpt1" VALUE 0x80284169 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_IgnClPsClUnExpt2_C "DFC / Reference of environment condition set for check DFC_IgnClPsClUnExpt2" VALUE 0x8028416A Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_IgnClPsClUnExpt3_C "DFC / Reference of environment condition set for check DFC_IgnClPsClUnExpt3" VALUE 0x8028416B Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_IgnClPsClUnExpt4_C "DFC / Reference of environment condition set for check DFC_IgnClPsClUnExpt4" VALUE 0x8028416C Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_IgnClPsClUnExpt5_C "DFC / Reference of environment condition set for check DFC_IgnClPsClUnExpt5" VALUE 0x8028416D Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_IgnClPsClUnExpt6_C "DFC / Reference of environment condition set for check DFC_IgnClPsClUnExpt6" VALUE 0x8028416E Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_IgnClPsClUnExpt7_C "DFC / Reference of environment condition set for check DFC_IgnClPsClUnExpt7" VALUE 0x8028416F Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_IgnClPsDevIdentErr1_C "DFC / Reference of environment condition set for check DFC_IgnClPsDevIdentErr1" VALUE 0x80284170 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_IgnClPsDevIdentErr2_C "DFC / Reference of environment condition set for check DFC_IgnClPsDevIdentErr2" VALUE 0x80284171 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_IgnClPsDevInitErr1_C "DFC / Reference of environment condition set for check DFC_IgnClPsDevInitErr1" VALUE 0x80284172 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_IgnClPsDevInitErr2_C "DFC / Reference of environment condition set for check DFC_IgnClPsDevInitErr2" VALUE 0x80284173 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_IgnClPsDevOscErr1_C "DFC / Reference of environment condition set for check DFC_IgnClPsDevOscErr1" VALUE 0x80284174 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_IgnClPsDevOscErr2_C "DFC / Reference of environment condition set for check DFC_IgnClPsDevOscErr2" VALUE 0x80284175 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_IgnClPsDevSpiErr1_C "DFC / Reference of environment condition set for check DFC_IgnClPsDevSpiErr1" VALUE 0x80284176 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_IgnClPsDevSpiErr2_C "DFC / Reference of environment condition set for check DFC_IgnClPsDevSpiErr2" VALUE 0x80284177 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_IgnClPsOpenLoad0_C "DFC / Reference of environment condition set for check DFC_IgnClPsOpenLoad0" VALUE 0x80284178 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_IgnClPsOpenLoad1_C "DFC / Reference of environment condition set for check DFC_IgnClPsOpenLoad1" VALUE 0x80284179 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_IgnClPsOpenLoad2_C "DFC / Reference of environment condition set for check DFC_IgnClPsOpenLoad2" VALUE 0x8028417A Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_IgnClPsOpenLoad3_C "DFC / Reference of environment condition set for check DFC_IgnClPsOpenLoad3" VALUE 0x8028417B Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_IgnClPsOpenLoad4_C "DFC / Reference of environment condition set for check DFC_IgnClPsOpenLoad4" VALUE 0x8028417C Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_IgnClPsOpenLoad5_C "DFC / Reference of environment condition set for check DFC_IgnClPsOpenLoad5" VALUE 0x8028417D Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_IgnClPsOpenLoad6_C "DFC / Reference of environment condition set for check DFC_IgnClPsOpenLoad6" VALUE 0x8028417E Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_IgnClPsOpenLoad7_C "DFC / Reference of environment condition set for check DFC_IgnClPsOpenLoad7" VALUE 0x8028417F Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_IgnClPsShCirBatt0_C "DFC / Reference of environment condition set for check DFC_IgnClPsShCirBatt0" VALUE 0x80284180 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_IgnClPsShCirBatt1_C "DFC / Reference of environment condition set for check DFC_IgnClPsShCirBatt1" VALUE 0x80284181 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_IgnClPsShCirBatt2_C "DFC / Reference of environment condition set for check DFC_IgnClPsShCirBatt2" VALUE 0x80284182 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_IgnClPsShCirBatt3_C "DFC / Reference of environment condition set for check DFC_IgnClPsShCirBatt3" VALUE 0x80284183 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_IgnClPsShCirBatt4_C "DFC / Reference of environment condition set for check DFC_IgnClPsShCirBatt4" VALUE 0x80284184 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_IgnClPsShCirBatt5_C "DFC / Reference of environment condition set for check DFC_IgnClPsShCirBatt5" VALUE 0x80284185 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_IgnClPsShCirBatt6_C "DFC / Reference of environment condition set for check DFC_IgnClPsShCirBatt6" VALUE 0x80284186 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_IgnClPsShCirBatt7_C "DFC / Reference of environment condition set for check DFC_IgnClPsShCirBatt7" VALUE 0x80284187 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_IgnClPsShCirGnd0_C "DFC / Reference of environment condition set for check DFC_IgnClPsShCirGnd0" VALUE 0x80284188 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_IgnClPsShCirGnd1_C "DFC / Reference of environment condition set for check DFC_IgnClPsShCirGnd1" VALUE 0x80284189 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_IgnClPsShCirGnd2_C "DFC / Reference of environment condition set for check DFC_IgnClPsShCirGnd2" VALUE 0x8028418A Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_IgnClPsShCirGnd3_C "DFC / Reference of environment condition set for check DFC_IgnClPsShCirGnd3" VALUE 0x8028418B Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_IgnClPsShCirGnd4_C "DFC / Reference of environment condition set for check DFC_IgnClPsShCirGnd4" VALUE 0x8028418C Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_IgnClPsShCirGnd5_C "DFC / Reference of environment condition set for check DFC_IgnClPsShCirGnd5" VALUE 0x8028418D Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_IgnClPsShCirGnd6_C "DFC / Reference of environment condition set for check DFC_IgnClPsShCirGnd6" VALUE 0x8028418E Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_IgnClPsShCirGnd7_C "DFC / Reference of environment condition set for check DFC_IgnClPsShCirGnd7" VALUE 0x8028418F Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_KnDetSens1PortAMax_C "DFC / Reference of environment condition set for check DFC_KnDetSens1PortAMax" VALUE 0x80284190 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_KnDetSens1PortAMin_C "DFC / Reference of environment condition set for check DFC_KnDetSens1PortAMin" VALUE 0x80284191 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_KnDetSens1PortBMax_C "DFC / Reference of environment condition set for check DFC_KnDetSens1PortBMax" VALUE 0x80284192 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_KnDetSens1PortBMin_C "DFC / Reference of environment condition set for check DFC_KnDetSens1PortBMin" VALUE 0x80284193 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_KnDetSens2PortAMax_C "DFC / Reference of environment condition set for check DFC_KnDetSens2PortAMax" VALUE 0x80284194 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_KnDetSens2PortAMin_C "DFC / Reference of environment condition set for check DFC_KnDetSens2PortAMin" VALUE 0x80284195 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_KnDetSens2PortBMax_C "DFC / Reference of environment condition set for check DFC_KnDetSens2PortBMax" VALUE 0x80284196 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_KnDetSens2PortBMin_C "DFC / Reference of environment condition set for check DFC_KnDetSens2PortBMin" VALUE 0x80284197 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_KnDetSens3PortAMax_C "DFC / Reference of environment condition set for check DFC_KnDetSens3PortAMax" VALUE 0x80284198 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_KnDetSens3PortAMin_C "DFC / Reference of environment condition set for check DFC_KnDetSens3PortAMin" VALUE 0x80284199 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_KnDetSens3PortBMax_C "DFC / Reference of environment condition set for check DFC_KnDetSens3PortBMax" VALUE 0x8028419A Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_KnDetSens3PortBMin_C "DFC / Reference of environment condition set for check DFC_KnDetSens3PortBMin" VALUE 0x8028419B Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_KnDetSens4PortAMax_C "DFC / Reference of environment condition set for check DFC_KnDetSens4PortAMax" VALUE 0x8028419C Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_KnDetSens4PortAMin_C "DFC / Reference of environment condition set for check DFC_KnDetSens4PortAMin" VALUE 0x8028419D Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_KnDetSens4PortBMax_C "DFC / Reference of environment condition set for check DFC_KnDetSens4PortBMax" VALUE 0x8028419E Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_KnDetSens4PortBMin_C "DFC / Reference of environment condition set for check DFC_KnDetSens4PortBMin" VALUE 0x8028419F Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_MfPsNonPlausible_C "DFC / Reference of environment condition set for check DFC_MfPsNonPlausible" VALUE 0x802841A0 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_MfPsNonPlausible2_C "DFC / Reference of environment condition set for check DFC_MfPsNonPlausible2" VALUE 0x802841A1 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_MfPsOpenLoad_C "DFC / Reference of environment condition set for check DFC_MfPsOpenLoad" VALUE 0x802841A2 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_MfPsOpenLoad2_C "DFC / Reference of environment condition set for check DFC_MfPsOpenLoad2" VALUE 0x802841A3 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_MfPsShCirBattLowSide_C "DFC / Reference of environment condition set for check DFC_MfPsShCirBattLowSide" VALUE 0x802841A4 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_MfPsShCirBattLowSide2_C "DFC / Reference of environment condition set for check DFC_MfPsShCirBattLowSide2" VALUE 0x802841A5 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_MfPsShCirGndLowSide_C "DFC / Reference of environment condition set for check DFC_MfPsShCirGndLowSide" VALUE 0x802841A6 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_MfPsShCirGndLowSide2_C "DFC / Reference of environment condition set for check DFC_MfPsShCirGndLowSide2" VALUE 0x802841A7 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_DevLibBattUHi_C "DFC / Reference of environment condition set for check DFC_DevLibBattUHi" VALUE 0x802841A8 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_DevLibBattULo_C "DFC / Reference of environment condition set for check DFC_DevLibBattULo" VALUE 0x802841A9 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_DSMDummy_C "DFC / Reference of environment condition set for check DFC_DSMDummy" VALUE 0x802841AA Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_EEPEraseErr_C "DFC / Reference of environment condition set for check DFC_EEPEraseErr" VALUE 0x802841AB Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_EEPRdErr_C "DFC / Reference of environment condition set for check DFC_EEPRdErr" VALUE 0x802841AC Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_EEPWrErr_C "DFC / Reference of environment condition set for check DFC_EEPWrErr" VALUE 0x802841AD Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_EV1max_C "DFC / Reference of environment condition set for check DFC_EV1max" VALUE 0x802841AE Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_EV1min_C "DFC / Reference of environment condition set for check DFC_EV1min" VALUE 0x802841AF Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_EV1sig_C "DFC / Reference of environment condition set for check DFC_EV1sig" VALUE 0x802841B0 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_EV2max_C "DFC / Reference of environment condition set for check DFC_EV2max" VALUE 0x802841B1 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_EV2min_C "DFC / Reference of environment condition set for check DFC_EV2min" VALUE 0x802841B2 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_EV2sig_C "DFC / Reference of environment condition set for check DFC_EV2sig" VALUE 0x802841B3 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_EV3max_C "DFC / Reference of environment condition set for check DFC_EV3max" VALUE 0x802841B4 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_EV3min_C "DFC / Reference of environment condition set for check DFC_EV3min" VALUE 0x802841B5 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_EV3sig_C "DFC / Reference of environment condition set for check DFC_EV3sig" VALUE 0x802841B6 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_EV4max_C "DFC / Reference of environment condition set for check DFC_EV4max" VALUE 0x802841B7 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_EV4min_C "DFC / Reference of environment condition set for check DFC_EV4min" VALUE 0x802841B8 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_EV4sig_C "DFC / Reference of environment condition set for check DFC_EV4sig" VALUE 0x802841B9 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_EV5max_C "DFC / Reference of environment condition set for check DFC_EV5max" VALUE 0x802841BA Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_EV5min_C "DFC / Reference of environment condition set for check DFC_EV5min" VALUE 0x802841BB Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_EV5sig_C "DFC / Reference of environment condition set for check DFC_EV5sig" VALUE 0x802841BC Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_EV6max_C "DFC / Reference of environment condition set for check DFC_EV6max" VALUE 0x802841BD Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_EV6min_C "DFC / Reference of environment condition set for check DFC_EV6min" VALUE 0x802841BE Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_EV6sig_C "DFC / Reference of environment condition set for check DFC_EV6sig" VALUE 0x802841BF Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_EV7max_C "DFC / Reference of environment condition set for check DFC_EV7max" VALUE 0x802841C0 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_EV7min_C "DFC / Reference of environment condition set for check DFC_EV7min" VALUE 0x802841C1 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_EV7sig_C "DFC / Reference of environment condition set for check DFC_EV7sig" VALUE 0x802841C2 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_EV8max_C "DFC / Reference of environment condition set for check DFC_EV8max" VALUE 0x802841C3 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_EV8min_C "DFC / Reference of environment condition set for check DFC_EV8min" VALUE 0x802841C4 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_EV8sig_C "DFC / Reference of environment condition set for check DFC_EV8sig" VALUE 0x802841C5 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_EpmCaSI1ErrSig_C "DFC / Reference of environment condition set for check DFC_EpmCaSI1ErrSig" VALUE 0x802841C6 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_EpmCaSI1NoSigMax_C "DFC / Reference of environment condition set for check DFC_EpmCaSI1NoSigMax" VALUE 0x802841C7 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_EpmCaSI1NoSigMin_C "DFC / Reference of environment condition set for check DFC_EpmCaSI1NoSigMin" VALUE 0x802841C8 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_EpmCaSI1OfsErr_C "DFC / Reference of environment condition set for check DFC_EpmCaSI1OfsErr" VALUE 0x802841C9 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_EpmCaSI2ErrSig_C "DFC / Reference of environment condition set for check DFC_EpmCaSI2ErrSig" VALUE 0x802841CA Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_EpmCaSI2NoSigMax_C "DFC / Reference of environment condition set for check DFC_EpmCaSI2NoSigMax" VALUE 0x802841CB Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_EpmCaSI2NoSigMin_C "DFC / Reference of environment condition set for check DFC_EpmCaSI2NoSigMin" VALUE 0x802841CC Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_EpmCaSI2OfsErr_C "DFC / Reference of environment condition set for check DFC_EpmCaSI2OfsErr" VALUE 0x802841CD Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_EpmCaSO1ErrSig_C "DFC / Reference of environment condition set for check DFC_EpmCaSO1ErrSig" VALUE 0x802841CE Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_EpmCaSO1NoSigMax_C "DFC / Reference of environment condition set for check DFC_EpmCaSO1NoSigMax" VALUE 0x802841CF Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_EpmCaSO1NoSigMin_C "DFC / Reference of environment condition set for check DFC_EpmCaSO1NoSigMin" VALUE 0x802841D0 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_EpmCaSO1OfsErr_C "DFC / Reference of environment condition set for check DFC_EpmCaSO1OfsErr" VALUE 0x802841D1 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_EpmCaSO2ErrSig_C "DFC / Reference of environment condition set for check DFC_EpmCaSO2ErrSig" VALUE 0x802841D2 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_EpmCaSO2NoSigMax_C "DFC / Reference of environment condition set for check DFC_EpmCaSO2NoSigMax" VALUE 0x802841D3 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_EpmCaSO2NoSigMin_C "DFC / Reference of environment condition set for check DFC_EpmCaSO2NoSigMin" VALUE 0x802841D4 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_EpmCaSO2OfsErr_C "DFC / Reference of environment condition set for check DFC_EpmCaSO2OfsErr" VALUE 0x802841D5 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_EpmCrSDGI_C "DFC / Reference of environment condition set for check DFC_EpmCrSDGI" VALUE 0x802841D6 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_EpmCrSErrSig_C "DFC / Reference of environment condition set for check DFC_EpmCrSErrSig" VALUE 0x802841D7 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_EpmCrSNoSig_C "DFC / Reference of environment condition set for check DFC_EpmCrSNoSig" VALUE 0x802841D8 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_HDEVH_MAX_0_C "DFC / Reference of environment condition set for check DFC_HDEVH_MAX_0" VALUE 0x802841D9 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_HDEVH_MAX_1_C "DFC / Reference of environment condition set for check DFC_HDEVH_MAX_1" VALUE 0x802841DA Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_HDEVH_MAX_2_C "DFC / Reference of environment condition set for check DFC_HDEVH_MAX_2" VALUE 0x802841DB Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_HDEVH_MAX_3_C "DFC / Reference of environment condition set for check DFC_HDEVH_MAX_3" VALUE 0x802841DC Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_HDEVH_MAX_4_C "DFC / Reference of environment condition set for check DFC_HDEVH_MAX_4" VALUE 0x802841DD Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_HDEVH_MAX_5_C "DFC / Reference of environment condition set for check DFC_HDEVH_MAX_5" VALUE 0x802841DE Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_HDEVH_MAX_6_C "DFC / Reference of environment condition set for check DFC_HDEVH_MAX_6" VALUE 0x802841DF Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_HDEVH_MAX_7_C "DFC / Reference of environment condition set for check DFC_HDEVH_MAX_7" VALUE 0x802841E0 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_HDEVH_MIN_0_C "DFC / Reference of environment condition set for check DFC_HDEVH_MIN_0" VALUE 0x802841E1 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_HDEVH_MIN_1_C "DFC / Reference of environment condition set for check DFC_HDEVH_MIN_1" VALUE 0x802841E2 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_HDEVH_MIN_2_C "DFC / Reference of environment condition set for check DFC_HDEVH_MIN_2" VALUE 0x802841E3 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_HDEVH_MIN_3_C "DFC / Reference of environment condition set for check DFC_HDEVH_MIN_3" VALUE 0x802841E4 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_HDEVH_MIN_4_C "DFC / Reference of environment condition set for check DFC_HDEVH_MIN_4" VALUE 0x802841E5 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_HDEVH_MIN_5_C "DFC / Reference of environment condition set for check DFC_HDEVH_MIN_5" VALUE 0x802841E6 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_HDEVH_MIN_6_C "DFC / Reference of environment condition set for check DFC_HDEVH_MIN_6" VALUE 0x802841E7 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_HDEVH_MIN_7_C "DFC / Reference of environment condition set for check DFC_HDEVH_MIN_7" VALUE 0x802841E8 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_HDEVH_NPL_0_C "DFC / Reference of environment condition set for check DFC_HDEVH_NPL_0" VALUE 0x802841E9 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_HDEVH_NPL_1_C "DFC / Reference of environment condition set for check DFC_HDEVH_NPL_1" VALUE 0x802841EA Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_HDEVH_NPL_2_C "DFC / Reference of environment condition set for check DFC_HDEVH_NPL_2" VALUE 0x802841EB Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_HDEVH_NPL_3_C "DFC / Reference of environment condition set for check DFC_HDEVH_NPL_3" VALUE 0x802841EC Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_HDEVH_NPL_4_C "DFC / Reference of environment condition set for check DFC_HDEVH_NPL_4" VALUE 0x802841ED Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_HDEVH_NPL_5_C "DFC / Reference of environment condition set for check DFC_HDEVH_NPL_5" VALUE 0x802841EE Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_HDEVH_NPL_6_C "DFC / Reference of environment condition set for check DFC_HDEVH_NPL_6" VALUE 0x802841EF Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_HDEVH_NPL_7_C "DFC / Reference of environment condition set for check DFC_HDEVH_NPL_7" VALUE 0x802841F0 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_HDEVL_MAX_0_C "DFC / Reference of environment condition set for check DFC_HDEVL_MAX_0" VALUE 0x802841F1 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_HDEVL_MAX_1_C "DFC / Reference of environment condition set for check DFC_HDEVL_MAX_1" VALUE 0x802841F2 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_HDEVL_MAX_2_C "DFC / Reference of environment condition set for check DFC_HDEVL_MAX_2" VALUE 0x802841F3 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_HDEVL_MAX_3_C "DFC / Reference of environment condition set for check DFC_HDEVL_MAX_3" VALUE 0x802841F4 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_HDEVL_MAX_4_C "DFC / Reference of environment condition set for check DFC_HDEVL_MAX_4" VALUE 0x802841F5 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_HDEVL_MAX_5_C "DFC / Reference of environment condition set for check DFC_HDEVL_MAX_5" VALUE 0x802841F6 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_HDEVL_MAX_6_C "DFC / Reference of environment condition set for check DFC_HDEVL_MAX_6" VALUE 0x802841F7 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_HDEVL_MAX_7_C "DFC / Reference of environment condition set for check DFC_HDEVL_MAX_7" VALUE 0x802841F8 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_HDEVL_MIN_0_C "DFC / Reference of environment condition set for check DFC_HDEVL_MIN_0" VALUE 0x802841F9 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_HDEVL_MIN_1_C "DFC / Reference of environment condition set for check DFC_HDEVL_MIN_1" VALUE 0x802841FA Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_HDEVL_MIN_2_C "DFC / Reference of environment condition set for check DFC_HDEVL_MIN_2" VALUE 0x802841FB Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_HDEVL_MIN_3_C "DFC / Reference of environment condition set for check DFC_HDEVL_MIN_3" VALUE 0x802841FC Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_HDEVL_MIN_4_C "DFC / Reference of environment condition set for check DFC_HDEVL_MIN_4" VALUE 0x802841FD Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_HDEVL_MIN_5_C "DFC / Reference of environment condition set for check DFC_HDEVL_MIN_5" VALUE 0x802841FE Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_HDEVL_MIN_6_C "DFC / Reference of environment condition set for check DFC_HDEVL_MIN_6" VALUE 0x802841FF Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_HDEVL_MIN_7_C "DFC / Reference of environment condition set for check DFC_HDEVL_MIN_7" VALUE 0x80284200 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_HDEVL_NPL_0_C "DFC / Reference of environment condition set for check DFC_HDEVL_NPL_0" VALUE 0x80284201 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_HDEVL_NPL_1_C "DFC / Reference of environment condition set for check DFC_HDEVL_NPL_1" VALUE 0x80284202 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_HDEVL_NPL_2_C "DFC / Reference of environment condition set for check DFC_HDEVL_NPL_2" VALUE 0x80284203 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_HDEVL_NPL_3_C "DFC / Reference of environment condition set for check DFC_HDEVL_NPL_3" VALUE 0x80284204 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_HDEVL_NPL_4_C "DFC / Reference of environment condition set for check DFC_HDEVL_NPL_4" VALUE 0x80284205 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_HDEVL_NPL_5_C "DFC / Reference of environment condition set for check DFC_HDEVL_NPL_5" VALUE 0x80284206 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_HDEVL_NPL_6_C "DFC / Reference of environment condition set for check DFC_HDEVL_NPL_6" VALUE 0x80284207 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_HDEVL_NPL_7_C "DFC / Reference of environment condition set for check DFC_HDEVL_NPL_7" VALUE 0x80284208 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_HDEVL_SIG_0_C "DFC / Reference of environment condition set for check DFC_HDEVL_SIG_0" VALUE 0x80284209 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_HDEVL_SIG_1_C "DFC / Reference of environment condition set for check DFC_HDEVL_SIG_1" VALUE 0x8028420A Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_HDEVL_SIG_2_C "DFC / Reference of environment condition set for check DFC_HDEVL_SIG_2" VALUE 0x8028420B Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_HDEVL_SIG_3_C "DFC / Reference of environment condition set for check DFC_HDEVL_SIG_3" VALUE 0x8028420C Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_HDEVL_SIG_4_C "DFC / Reference of environment condition set for check DFC_HDEVL_SIG_4" VALUE 0x8028420D Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_HDEVL_SIG_5_C "DFC / Reference of environment condition set for check DFC_HDEVL_SIG_5" VALUE 0x8028420E Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_HDEVL_SIG_6_C "DFC / Reference of environment condition set for check DFC_HDEVL_SIG_6" VALUE 0x8028420F Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_HDEVL_SIG_7_C "DFC / Reference of environment condition set for check DFC_HDEVL_SIG_7" VALUE 0x80284210 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_HSFE2max_C "DFC / Reference of environment condition set for check DFC_HSFE2max" VALUE 0x80284211 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_HSFE2min_C "DFC / Reference of environment condition set for check DFC_HSFE2min" VALUE 0x80284212 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_HSFE2sig_C "DFC / Reference of environment condition set for check DFC_HSFE2sig" VALUE 0x80284213 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_HSFEmax_C "DFC / Reference of environment condition set for check DFC_HSFEmax" VALUE 0x80284214 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_HSFEmin_C "DFC / Reference of environment condition set for check DFC_HSFEmin" VALUE 0x80284215 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_HSFEsig_C "DFC / Reference of environment condition set for check DFC_HSFEsig" VALUE 0x80284216 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_HSHE2max_C "DFC / Reference of environment condition set for check DFC_HSHE2max" VALUE 0x80284217 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_HSHE2min_C "DFC / Reference of environment condition set for check DFC_HSHE2min" VALUE 0x80284218 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_HSHE2sig_C "DFC / Reference of environment condition set for check DFC_HSHE2sig" VALUE 0x80284219 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_HSHEmax_C "DFC / Reference of environment condition set for check DFC_HSHEmax" VALUE 0x8028421A Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_HSHEmin_C "DFC / Reference of environment condition set for check DFC_HSHEmin" VALUE 0x8028421B Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_HSHEsig_C "DFC / Reference of environment condition set for check DFC_HSHEsig" VALUE 0x8028421C Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_HSVE2max_C "DFC / Reference of environment condition set for check DFC_HSVE2max" VALUE 0x8028421D Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_HSVE2maxLSF_C "DFC / Reference of environment condition set for check DFC_HSVE2maxLSF" VALUE 0x8028421E Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_HSVE2min_C "DFC / Reference of environment condition set for check DFC_HSVE2min" VALUE 0x8028421F Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_HSVE2minLSF_C "DFC / Reference of environment condition set for check DFC_HSVE2minLSF" VALUE 0x80284220 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_HSVE2sig_C "DFC / Reference of environment condition set for check DFC_HSVE2sig" VALUE 0x80284221 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_HSVE2sigLSF_C "DFC / Reference of environment condition set for check DFC_HSVE2sigLSF" VALUE 0x80284222 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_HSVEmax_C "DFC / Reference of environment condition set for check DFC_HSVEmax" VALUE 0x80284223 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_HSVEmaxLSF_C "DFC / Reference of environment condition set for check DFC_HSVEmaxLSF" VALUE 0x80284224 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_HSVEmin_C "DFC / Reference of environment condition set for check DFC_HSVEmin" VALUE 0x80284225 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_HSVEminLSF_C "DFC / Reference of environment condition set for check DFC_HSVEminLSF" VALUE 0x80284226 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_HSVEsig_C "DFC / Reference of environment condition set for check DFC_HSVEsig" VALUE 0x80284227 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_HSVEsigLSF_C "DFC / Reference of environment condition set for check DFC_HSVEsigLSF" VALUE 0x80284228 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_ICLSU2max_C "DFC / Reference of environment condition set for check DFC_ICLSU2max" VALUE 0x80284229 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_ICLSU2min_C "DFC / Reference of environment condition set for check DFC_ICLSU2min" VALUE 0x8028422A Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_ICLSU2npl_C "DFC / Reference of environment condition set for check DFC_ICLSU2npl" VALUE 0x8028422B Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_ICLSU2sig_C "DFC / Reference of environment condition set for check DFC_ICLSU2sig" VALUE 0x8028422C Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_ICLSUmax_C "DFC / Reference of environment condition set for check DFC_ICLSUmax" VALUE 0x8028422D Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_ICLSUmin_C "DFC / Reference of environment condition set for check DFC_ICLSUmin" VALUE 0x8028422E Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_ICLSUnpl_C "DFC / Reference of environment condition set for check DFC_ICLSUnpl" VALUE 0x8028422F Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_ICLSUsig_C "DFC / Reference of environment condition set for check DFC_ICLSUsig" VALUE 0x80284230 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_LSF2max_C "DFC / Reference of environment condition set for check DFC_LSF2max" VALUE 0x80284231 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_LSF2min_C "DFC / Reference of environment condition set for check DFC_LSF2min" VALUE 0x80284232 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_LSF2npl_C "DFC / Reference of environment condition set for check DFC_LSF2npl" VALUE 0x80284233 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_LSF2sig_C "DFC / Reference of environment condition set for check DFC_LSF2sig" VALUE 0x80284234 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_LSFmax_C "DFC / Reference of environment condition set for check DFC_LSFmax" VALUE 0x80284235 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_LSFmin_C "DFC / Reference of environment condition set for check DFC_LSFmin" VALUE 0x80284236 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_LSFnpl_C "DFC / Reference of environment condition set for check DFC_LSFnpl" VALUE 0x80284237 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_LSFsig_C "DFC / Reference of environment condition set for check DFC_LSFsig" VALUE 0x80284238 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_LSH2max_C "DFC / Reference of environment condition set for check DFC_LSH2max" VALUE 0x80284239 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_LSH2min_C "DFC / Reference of environment condition set for check DFC_LSH2min" VALUE 0x8028423A Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_LSH2npl_C "DFC / Reference of environment condition set for check DFC_LSH2npl" VALUE 0x8028423B Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_LSH2sig_C "DFC / Reference of environment condition set for check DFC_LSH2sig" VALUE 0x8028423C Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_LSHmax_C "DFC / Reference of environment condition set for check DFC_LSHmax" VALUE 0x8028423D Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_LSHmin_C "DFC / Reference of environment condition set for check DFC_LSHmin" VALUE 0x8028423E Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_LSHnpl_C "DFC / Reference of environment condition set for check DFC_LSHnpl" VALUE 0x8028423F Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_LSHsig_C "DFC / Reference of environment condition set for check DFC_LSHsig" VALUE 0x80284240 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_LSUIA2sig_C "DFC / Reference of environment condition set for check DFC_LSUIA2sig" VALUE 0x80284241 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_LSUIAsig_C "DFC / Reference of environment condition set for check DFC_LSUIAsig" VALUE 0x80284242 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_LSUIP2max_C "DFC / Reference of environment condition set for check DFC_LSUIP2max" VALUE 0x80284243 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_LSUIP2npl_C "DFC / Reference of environment condition set for check DFC_LSUIP2npl" VALUE 0x80284244 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_LSUIP2sig_C "DFC / Reference of environment condition set for check DFC_LSUIP2sig" VALUE 0x80284245 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_LSUIPmax_C "DFC / Reference of environment condition set for check DFC_LSUIPmax" VALUE 0x80284246 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_LSUIPnpl_C "DFC / Reference of environment condition set for check DFC_LSUIPnpl" VALUE 0x80284247 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_LSUIPsig_C "DFC / Reference of environment condition set for check DFC_LSUIPsig" VALUE 0x80284248 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_LSUKS2max_C "DFC / Reference of environment condition set for check DFC_LSUKS2max" VALUE 0x80284249 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_LSUKS2min_C "DFC / Reference of environment condition set for check DFC_LSUKS2min" VALUE 0x8028424A Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_LSUKSmax_C "DFC / Reference of environment condition set for check DFC_LSUKSmax" VALUE 0x8028424B Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_LSUKSmin_C "DFC / Reference of environment condition set for check DFC_LSUKSmin" VALUE 0x8028424C Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_LSUUN2sig_C "DFC / Reference of environment condition set for check DFC_LSUUN2sig" VALUE 0x8028424D Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_LSUUNsig_C "DFC / Reference of environment condition set for check DFC_LSUUNsig" VALUE 0x8028424E Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_LSUVM2sig_C "DFC / Reference of environment condition set for check DFC_LSUVM2sig" VALUE 0x8028424F Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_LSUVMsig_C "DFC / Reference of environment condition set for check DFC_LSUVMsig" VALUE 0x80284250 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_LSV2max_C "DFC / Reference of environment condition set for check DFC_LSV2max" VALUE 0x80284251 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_LSV2min_C "DFC / Reference of environment condition set for check DFC_LSV2min" VALUE 0x80284252 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_LSV2npl_C "DFC / Reference of environment condition set for check DFC_LSV2npl" VALUE 0x80284253 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_LSV2sig_C "DFC / Reference of environment condition set for check DFC_LSV2sig" VALUE 0x80284254 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_LSVmax_C "DFC / Reference of environment condition set for check DFC_LSVmax" VALUE 0x80284255 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_LSVmin_C "DFC / Reference of environment condition set for check DFC_LSVmin" VALUE 0x80284256 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_LSVnpl_C "DFC / Reference of environment condition set for check DFC_LSVnpl" VALUE 0x80284257 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_LSVsig_C "DFC / Reference of environment condition set for check DFC_LSVsig" VALUE 0x80284258 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_MD00max_C "DFC / Reference of environment condition set for check DFC_MD00max" VALUE 0x80284259 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_MD00min_C "DFC / Reference of environment condition set for check DFC_MD00min" VALUE 0x8028425A Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_MD00npl_C "DFC / Reference of environment condition set for check DFC_MD00npl" VALUE 0x8028425B Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_MD01max_C "DFC / Reference of environment condition set for check DFC_MD01max" VALUE 0x8028425C Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_MD01min_C "DFC / Reference of environment condition set for check DFC_MD01min" VALUE 0x8028425D Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_MD01npl_C "DFC / Reference of environment condition set for check DFC_MD01npl" VALUE 0x8028425E Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_MD02max_C "DFC / Reference of environment condition set for check DFC_MD02max" VALUE 0x8028425F Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_MD02min_C "DFC / Reference of environment condition set for check DFC_MD02min" VALUE 0x80284260 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_MD02npl_C "DFC / Reference of environment condition set for check DFC_MD02npl" VALUE 0x80284261 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_MD03max_C "DFC / Reference of environment condition set for check DFC_MD03max" VALUE 0x80284262 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_MD03min_C "DFC / Reference of environment condition set for check DFC_MD03min" VALUE 0x80284263 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_MD03npl_C "DFC / Reference of environment condition set for check DFC_MD03npl" VALUE 0x80284264 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_MD04max_C "DFC / Reference of environment condition set for check DFC_MD04max" VALUE 0x80284265 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_MD04min_C "DFC / Reference of environment condition set for check DFC_MD04min" VALUE 0x80284266 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_MD04npl_C "DFC / Reference of environment condition set for check DFC_MD04npl" VALUE 0x80284267 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_MD05max_C "DFC / Reference of environment condition set for check DFC_MD05max" VALUE 0x80284268 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_MD05min_C "DFC / Reference of environment condition set for check DFC_MD05min" VALUE 0x80284269 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_MD05npl_C "DFC / Reference of environment condition set for check DFC_MD05npl" VALUE 0x8028426A Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_MD06max_C "DFC / Reference of environment condition set for check DFC_MD06max" VALUE 0x8028426B Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_MD06min_C "DFC / Reference of environment condition set for check DFC_MD06min" VALUE 0x8028426C Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_MD06npl_C "DFC / Reference of environment condition set for check DFC_MD06npl" VALUE 0x8028426D Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_MD07max_C "DFC / Reference of environment condition set for check DFC_MD07max" VALUE 0x8028426E Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_MD07min_C "DFC / Reference of environment condition set for check DFC_MD07min" VALUE 0x8028426F Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_MD07npl_C "DFC / Reference of environment condition set for check DFC_MD07npl" VALUE 0x80284270 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_MDmax_C "DFC / Reference of environment condition set for check DFC_MDmax" VALUE 0x80284271 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_MDmin_C "DFC / Reference of environment condition set for check DFC_MDmin" VALUE 0x80284272 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_MDnpl_C "DFC / Reference of environment condition set for check DFC_MDnpl" VALUE 0x80284273 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_MRlyErlyOpng_C "DFC / Reference of environment condition set for check DFC_MRlyErlyOpng" VALUE 0x80284274 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_MRlyStk_C "DFC / Reference of environment condition set for check DFC_MRlyStk" VALUE 0x80284275 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_PLLSUmax_C "DFC / Reference of environment condition set for check DFC_PLLSUmax" VALUE 0x80284276 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_PLLSUmin_C "DFC / Reference of environment condition set for check DFC_PLLSUmin" VALUE 0x80284277 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_PLLSUnpl_C "DFC / Reference of environment condition set for check DFC_PLLSUnpl" VALUE 0x80284278 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_PLLSUsig_C "DFC / Reference of environment condition set for check DFC_PLLSUsig" VALUE 0x80284279 Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin CHARACTERISTIC DFES_EnvRef.DFC_SWReset_0_C "DFC / Reference of environment condition set for check DFC_SWReset_0" VALUE 0x8028427A Val_Wu8 49. DFES_EnvTabVerb 0.00 49. FORMAT "%2.0" /end CHARACTERISTIC
/begin COMPU_METHOD DFES_EnvTabVerb "" TAB_VERB "%2.1" "-" COMPU_TAB_REF DFES_EnvTabVerb /end COMPU_METHOD
/begin COMPU_VTAB DFES_EnvTabVerb "" TAB_VERB 50 0 "xSet1" 1 "xSet2" 2 "xSet3" 3 "xSet4" 4 "xSet5" 5 "xSet6" 6 "xSet7" 7 "xSet8" 8 "xSet9" 9 "xSet10" 10 "xSet11" 11 "xSet12" 12 "xSet13" 13 "xSet14" 14 "xSet15" 15 "xSet16" 16 "xSet17" 17 "xSet18" 18 "xSet19" 19 "xSet20" 20 "xSet21" 21 "xSet22" 22 "xSet23" 23 "xSet24" 24 "xSet25" 25 "xSet26" 26 "xSet27" 27 "xSet28" 28 "xSet29" 29 "xSet30" 30 "xSet31" 31 "xSet32" 32 "xSet33" 33 "xSet34" 34 "xSet35" 35 "xSet36" 36 "xSet37" 37 "xSet38" 38 "xSet39" 39 "xSet40" 40 "xSet41" 41 "xSet42" 42 "xSet43" 43 "xSet44" 44 "xSet45" 45 "xSet46" 46 "xSet47" 47 "xSet48" 48 "xSet49" 49 "xSet50" DEFAULT_VALUE "---" /end COMPU_VTAB
/begin COMPU_METHOD DFES_OneToOne "" RAT_FUNC "%6.2" "-" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD EffGradPrc "" RAT_FUNC "%8.7" "1/s" COEFFS 0 819200 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD EGTFact "" RAT_FUNC "%6.5" "-" COEFFS 0 1000 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD EGTSwt "" RAT_FUNC "%10.9" "-" COEFFS 0 16384000 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD EGTSwt_S16 "" RAT_FUNC "%7.6" "-" COEFFS 0 16384 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD Energy "" RAT_FUNC "%6.2" "kJ" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD Energy_J_HiRes "" RAT_FUNC "%6.2" "J" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD Energy_q0p0001 "" RAT_FUNC "%7.6" "kJ" COEFFS 0 10000 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD Energy_q0p001_COMPU "" RAT_FUNC "%6.5" "kJ" COEFFS 0 1000 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD EngN2tiIncPer "" RAT_FUNC "%8.0" "rpm" COEFFS 0 0 1 0 4.0000002e-007 0 /end COMPU_METHOD
/begin COMPU_METHOD EngNCaS "" RAT_FUNC "%6.3" "CaSrpm" COEFFS 0 4 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD EngNRmp_Hi "" RAT_FUNC "%6.3" "rpm" COEFFS 0 10 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD EngN_HiRes "" RAT_FUNC "%6.4" "rpm" COEFFS 0 32 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD ENGRESTRT_SY_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF ENGRESTRT_SY_Compu /end COMPU_METHOD
/begin COMPU_VTAB ENGRESTRT_SY_Compu "" TAB_VERB 2 0 "False" 1 "True" /end COMPU_VTAB
/begin COMPU_METHOD ENGSPD_SWTENA_SY_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF ENGSPD_SWTENA_SY_Compu /end COMPU_METHOD
/begin COMPU_VTAB ENGSPD_SWTENA_SY_Compu "" TAB_VERB 2 0 "FALSE" 1 "TRUE" /end COMPU_VTAB
/begin COMPU_METHOD EnrgPerMass "" RAT_FUNC "%6.3" "MJ/Kg" COEFFS 0 10 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD EnrgPrMol_q0p001_COMPU "" RAT_FUNC "%6.5" "J/mol" COEFFS 0 1000 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD EPMBCA_FACSEGTIMEACC_CURX_SC_Compu "" RAT_FUNC "%6.2" "" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD EPMCAS_FACPLAUS_DSTX_SC_Compu "" RAT_FUNC "%6.2" "" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD EpmCaS_Fac_Adap "" RAT_FUNC "%6.5" "-" COEFFS 0 1000 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD EpmCaS_Fac_Plaus "" RAT_FUNC "%6.5" "-" COEFFS 0 1000 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD EPMCAS_NUMSEGLEN_SC_Compu "" RAT_FUNC "%6.2" "" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD EPMCAS_NUMSEG_SC_Compu "" RAT_FUNC "%6.2" "" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD EPMCAS_PHINCOR_CURX_SC_Compu "" RAT_FUNC "%6.2" "" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD EPMCAS_PHITEMPCOR05_DSTX_SC_Compu "" RAT_FUNC "%6.2" "" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD EPMCRS_REVSTRTCONT_SC_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF EPMCRS_REVSTRTCONT_SC_Compu /end COMPU_METHOD
/begin COMPU_VTAB EPMCRS_REVSTRTCONT_SC_Compu "" TAB_VERB 2 0 "False" 1 "True" /end COMPU_VTAB
/begin COMPU_METHOD EPMHWE_RTM_SY_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF EPMHWE_RTM_SY_Compu /end COMPU_METHOD
/begin COMPU_VTAB EPMHWE_RTM_SY_Compu "" TAB_VERB 2 0 "NO_RTM" 1 "RTM" /end COMPU_VTAB
/begin COMPU_METHOD EPMHWE_SWTCPU_SY_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF EPMHWE_SWTCPU_SY_Compu /end COMPU_METHOD
/begin COMPU_VTAB EPMHWE_SWTCPU_SY_Compu "" TAB_VERB 2 0 "PCP" 1 "CPU" /end COMPU_VTAB
/begin COMPU_METHOD EPMRRS_SY_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF EPMRRS_SY_Compu /end COMPU_METHOD
/begin COMPU_VTAB EPMRRS_SY_Compu "" TAB_VERB 5 0 "no function" 1 "backward rotation detection" 2 "backward rotation detection and engine stop angle" 3 "DGI: backward rotation detection" 4 "DGI: backward rotation & engine stop angle detecti" /end COMPU_VTAB
/begin COMPU_METHOD EPMRRS_TITEMP_CURX_SC_Compu "" RAT_FUNC "%6.2" "" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD EPMRVSROTYMETH_SY_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF EPMRVSROTYMETH_SY_Compu /end COMPU_METHOD
/begin COMPU_VTAB EPMRVSROTYMETH_SY_Compu "" TAB_VERB 2 0 "TOOTHPERD" 1 "PLSTI" /end COMPU_VTAB
/begin COMPU_METHOD EpmSrv_stCnvAgT2Ag_t "" TAB_VERB "%6.3" "" COMPU_TAB_REF EpmSrv_stCnvAgT2Ag_t /end COMPU_METHOD
/begin COMPU_VTAB EpmSrv_stCnvAgT2Ag_t "" TAB_VERB 30 0 "0" 1 "1" 2 "2" 3 "3" 4 "4" 5 "5" 6 "6" 7 "7" 8 "8" 9 "9" 10 "10" 11 "11" 12 "12" 13 "13" 14 "14" 15 "15" 16 "16" 17 "17" 18 "18" 19 "19" 20 "20" 21 "21" 22 "22" 23 "23" 24 "24" 25 "AVRGSPD" 26 "EXTRAPOLATION" 253 "ERRORSTGY" 254 "ERRORCRS" 255 "ERRORMIAP" /end COMPU_VTAB
/begin COMPU_METHOD EPMSYN_PHIINCCOR_CURX_SC_Compu "" RAT_FUNC "%6.2" "" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD EpmSyn_stRRComp "" TAB_VERB "%6.3" "" COMPU_TAB_REF EpmSyn_stRRComp /end COMPU_METHOD
/begin COMPU_VTAB EpmSyn_stRRComp "" TAB_VERB 2 0 "EPMSYN_FORWARDS" 1 "EPMSYN_BACKWARDS" /end COMPU_VTAB
/begin COMPU_METHOD EPM_ATS_SY_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF EPM_ATS_SY_Compu /end COMPU_METHOD
/begin COMPU_VTAB EPM_ATS_SY_Compu "" TAB_VERB 2 0 "False" 1 "True" /end COMPU_VTAB
/begin COMPU_METHOD EPM_DIAGSPC_SY_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF EPM_DIAGSPC_SY_Compu /end COMPU_METHOD
/begin COMPU_VTAB EPM_DIAGSPC_SY_Compu "" TAB_VERB 4 0 "NOSPC" 1 "SPCCRS" 2 "SPCCAS" 3 "SPCCRSCAS" /end COMPU_VTAB
/begin COMPU_METHOD EPM_GTCRED_SY_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF EPM_GTCRED_SY_Compu /end COMPU_METHOD
/begin COMPU_VTAB EPM_GTCRED_SY_Compu "" TAB_VERB 2 0 "No GTC reduction" 1 "GTC reduction for CaS" /end COMPU_VTAB
/begin COMPU_METHOD EPM_KEEPDGISYNC_SC_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF EPM_KEEPDGISYNC_SC_Compu /end COMPU_METHOD
/begin COMPU_VTAB EPM_KEEPDGISYNC_SC_Compu "" TAB_VERB 2 0 "STD" 1 "KEEPDGISYNC" /end COMPU_VTAB
/begin COMPU_METHOD EPM_MEASURE_SY_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF EPM_MEASURE_SY_Compu /end COMPU_METHOD
/begin COMPU_VTAB EPM_MEASURE_SY_Compu "" TAB_VERB 3 0 "0" 1 "1" 2 "2" /end COMPU_VTAB
/begin COMPU_METHOD EPM_SPD_CALC_SY_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF EPM_SPD_CALC_SY_Compu /end COMPU_METHOD
/begin COMPU_VTAB EPM_SPD_CALC_SY_Compu "" TAB_VERB 2 0 "IGNEDGE" 1 "WAITGAP" /end COMPU_VTAB
/begin COMPU_METHOD Epm_stReSyncReason_State_t "" TAB_VERB "%6.3" "" COMPU_TAB_REF Epm_stReSyncReason_State_t /end COMPU_METHOD
/begin COMPU_VTAB Epm_stReSyncReason_State_t "" TAB_VERB 8 0 "EPM_RESYNC_NORESYNC" 1 "EPM_RESYNC_NOCRS" 2 "EPM_RESYNC_SHIFT" 3 "EPM_RESYNC_NOPHASE" 4 "EPM_RESYNC_REVERSE" 5 "EPM_RESYNC_OFSERR" 6 "EPM_RESYNC_CANERR" 7 "EPM_RESYNC_UPPERLVL" /end COMPU_VTAB
/begin COMPU_METHOD EPM_SYNCSLV_SY_Compu "" RAT_FUNC "%6.2" "" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD EPM_TDCDSTCLB_SC_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF EPM_TDCDSTCLB_SC_Compu /end COMPU_METHOD
/begin COMPU_VTAB EPM_TDCDSTCLB_SC_Compu "" TAB_VERB 2 0 "STANDARD" 1 "ARRAY" /end COMPU_VTAB
/begin COMPU_METHOD EPM_TIMING_SY_Compu "" RAT_FUNC "%6.2" "" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD EPM_VAR_SY_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF EPM_VAR_SY_Compu /end COMPU_METHOD
/begin COMPU_VTAB EPM_VAR_SY_Compu "" TAB_VERB 29 1 "DAI" 3 "VWW" 4 "POR" 5 "AUD" 6 "OPE" 9 "FIA" 11 "BMW" 15 "REN" 17 "ALF" 18 "SAB" 19 "VOL" 20 "NIS" 21 "GMU" 22 "FOR" 51 "SEA" 55 "ROL" 69 "FER" 72 "TOY" 123 "MIT" 147 "HYU" 159 "HON" 160 "MAZ" 204 "VVW" 214 "AVT" 248 "SUZ" 289 "AMG" 308 "TAT" 564 "PSA" 999 "ALL" /end COMPU_VTAB
/begin COMPU_METHOD Eta "" RAT_FUNC "%6.4" "Nm/(mg/cyc)" COEFFS 0 128 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD Eta1 "" RAT_FUNC "%6.4" "-" COEFFS 0 128 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD Eta2 "" RAT_FUNC "%6.4" "" COEFFS 0 128 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD ETCtlGovKd_fac "" RAT_FUNC "%7.6" "-" COEFFS 0 12800 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD ETCtlGovKi_fac "" RAT_FUNC "%8.7" "-" COEFFS 0 429496.7296 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD ETCtlGovKp_fac "" RAT_FUNC "%7.6" "-" COEFFS 0 25600 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD ETCtlGovRmp "" RAT_FUNC "%6.3" "s" COEFFS 0 0 1 0 0.0152587890625 0 /end COMPU_METHOD
/begin COMPU_METHOD ETCtlGov_p0q001 "" RAT_FUNC "%6.5" "-" COEFFS 0 1000 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD ETC_Act_SY_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF ETC_Act_SY_Compu /end COMPU_METHOD
/begin COMPU_VTAB ETC_Act_SY_Compu "" TAB_VERB 2 0 "False" 1 "True" /end COMPU_VTAB
/begin COMPU_METHOD ETKS_SY_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF ETKS_SY_Compu /end COMPU_METHOD
/begin COMPU_VTAB ETKS_SY_Compu "" TAB_VERB 2 0 "No ETKS" 1 "ETKS" /end COMPU_VTAB
/begin COMPU_METHOD ETS_LEAN_SY_Compu "" RAT_FUNC "%6.2" "" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD ETS_NSC_SY_Compu "" RAT_FUNC "%6.2" "" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD ETS_PFLT1_SY_Compu "" RAT_FUNC "%6.2" "" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD ETS_PFLT2_SY_Compu "" RAT_FUNC "%6.2" "" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD ETS_PHC_SY_Compu "" RAT_FUNC "%6.2" "" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD ETS_SOX_SY_Compu "" RAT_FUNC "%6.2" "" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD EXHFLP_TYPAVLACTRLIB_SY_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF EXHFLP_TYPAVLACTRLIB_SY_Compu /end COMPU_METHOD
/begin COMPU_VTAB EXHFLP_TYPAVLACTRLIB_SY_Compu "" TAB_VERB 2 0 "FALSE" 1 "TRUE" /end COMPU_VTAB
/begin COMPU_METHOD EXHMOD_TSPS1_SC_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF EXHMOD_TSPS1_SC_Compu /end COMPU_METHOD
/begin COMPU_VTAB EXHMOD_TSPS1_SC_Compu "" TAB_VERB 2 0 "False" 1 "True" /end COMPU_VTAB
/begin COMPU_METHOD FacReactVel_COMPU "" RAT_FUNC "%6.2" "mol/s/m" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD FacReactVel_q100p0_COMPU "" RAT_FUNC "%6.0" "mol/s/m" COEFFS 0 0.01 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD Fact0002 "" RAT_FUNC "%6.5" "-" COEFFS 0 5000 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD Fact1 "" RAT_FUNC "%6.4" "-" COEFFS 0 128 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD Fact10 "" RAT_FUNC "%13.12" "-" COEFFS 0 10000000000 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD Fact100 "" RAT_FUNC "%6.4" "-" COEFFS 0 100 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD Fact1000 "" RAT_FUNC "%6.5" "-" COEFFS 0 1000 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD Fact16384_COMPU "" RAT_FUNC "%7.6" "%/hPa" COEFFS 0 16384 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD Fact255_COMPU "" RAT_FUNC "%6.4" "-" COEFFS 0 255 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD Fact256 "" RAT_FUNC "%6.4" "-" COEFFS 0 256 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD Fact26 "" RAT_FUNC "%10.9" "-" COEFFS 0 67108864 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD Fact3 "" RAT_FUNC "%6.4" "-" COEFFS 0 100 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD Fact4 "" RAT_FUNC "%6.4" "-" COEFFS 0 20 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD Fact5 "" RAT_FUNC "%6.3" "-" COEFFS 0 2 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD Fact6 "" RAT_FUNC "%6.4" "-" COEFFS 0 500 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD Fact7 "" RAT_FUNC "%10.9" "-" COEFFS 0 10000000 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD Fact8 "" RAT_FUNC "%11.10" "-" COEFFS 0 100000000 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD Fact9 "" RAT_FUNC "%6.5" "-" COEFFS 0 5000 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD FactFine "" RAT_FUNC "%9.8" "-" COEFFS 0 1000000 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD FactLow "" RAT_FUNC "%6.5" "-" COEFFS 0 1024 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD Signals_IntSigNumVerb "" TAB_VERB "%6.3" "" COMPU_TAB_REF Signals_IntSigNumVerb /end COMPU_METHOD
/begin COMPU_VTAB Signals_IntSigNumVerb "" TAB_VERB 37 0 "SIGNALS_Signals_Default" 1 "SIGNALS_EpmCaS_phiOfsCorr" 2 "SIGNALS_EpmCaS_phiOfsCorr_2" 3 "SIGNALS_EpmCaS_phiOfsCorr_3" 4 "SIGNALS_EpmCaS_phiOfsCorr_4" 5 "SIGNALS_Epm_nEng" 6 "SIGNALS_Epm_stOpMode" 7 "SIGNALS_Epm_stSync" 8 "SIGNALS_I15031_FILLSIG1h" 9 "SIGNALS_I15031_FILLSIG2h" 10 "SIGNALS_I15031_FILLSIG4h" 11 "SIGNALS_PID01h" 12 "SIGNALS_PID14h_0" 13 "SIGNALS_PID15h_0" 14 "SIGNALS_PID16h_0" 15 "SIGNALS_PID18h_0" 16 "SIGNALS_PID19h_0" 17 "SIGNALS_PID1Ah_0" 18 "SIGNALS_PID1Ch" 19 "SIGNALS_PID21h" 20 "SIGNALS_PID30h" 21 "SIGNALS_PID31h" 22 "SIGNALS_PID34h_0" 23 "SIGNALS_PID34h_1" 24 "SIGNALS_PID38h_0" 25 "SIGNALS_PID38h_1" 26 "SIGNALS_PID41h" 27 "SIGNALS_PID4FAh" 28 "SIGNALS_PID4FBh" 29 "SIGNALS_PID4FCh" 30 "SIGNALS_PID4FDh" 31 "SIGNALS_PID50Ah" 32 "SIGNALS_PID50Bh" 33 "SIGNALS_PID50Ch" 34 "SIGNALS_PID50Dh" 35 "SIGNALS_PID5Fh" 36 "SIGNALS_T15_stRaw" /end COMPU_VTAB
/begin RECORD_LAYOUT ValA_Wu16 FNC_VALUES 1 UWORD COLUMN_DIR DIRECT /end RECORD_LAYOUT
/begin RECORD_LAYOUT Val_Wu16 FNC_VALUES 1 UWORD COLUMN_DIR DIRECT /end RECORD_LAYOUT
/begin RECORD_LAYOUT Val_Wu8 FNC_VALUES 1 UBYTE COLUMN_DIR DIRECT /end RECORD_LAYOUT
/end MODULE
/end PROJECT
