ASAP2_VERSION 1 4
/begin PROJECT MED1734_Flx_G1 "MEDC17_Core"
/begin HEADER "" VERSION "MED1734_Flx_01" PROJECT_NO MED1734_Flx_G1 /end HEADER
/begin MODULE DIM ""
/begin MOD_COMMON "" BYTE_ORDER MSB_LAST ALIGNMENT_BYTE 1 ALIGNMENT_WORD 2 ALIGNMENT_LONG 4 ALIGNMENT_FLOAT32_IEEE 4 /end MOD_COMMON
/begin MEASUREMENT Frm_stCANG4_HDL8Rdy "Enable/Ready bit of the message buffer for Group 4 and Hanlde 8" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD00004F2 /end MEASUREMENT
/begin MEASUREMENT Frm_stCANG4_HDL9Rdy "Enable/Ready bit of the message buffer for Group 4 and Hanlde 9" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD00004F3 /end MEASUREMENT
/begin MEASUREMENT frm_w "fast mean value of lambda control factor (word)" UWORD fak_uw_b2 1 100 0.00 1.999969 FORMAT "%8.6" ECU_ADDRESS 0xD000165E /end MEASUREMENT
/begin MEASUREMENT frsnast2_w "" UWORD fak_uw_b2 1 100 0.00 1.999969 FORMAT "%8.6" ECU_ADDRESS 0xD0000C80 /end MEASUREMENT
/begin MEASUREMENT frsnast_w "" UWORD fak_uw_b2 1 100 0.00 1.999969 FORMAT "%8.6" ECU_ADDRESS 0xD0000C82 /end MEASUREMENT
/begin MEASUREMENT frstinjcyl "cylinder number first injection" UBYTE dez 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD00017D7 /end MEASUREMENT
/begin MEASUREMENT fubaanz "Number of follow up sparks during sparkband mode" UBYTE dez 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD000185A /end MEASUREMENT
/begin MEASUREMENT GGLSF2ZA.B_enrin "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD000093C /end MEASUREMENT
/begin MEASUREMENT GGLSF2ZA.B_lpcalc "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x8 FORMAT "%13.11" ECU_ADDRESS 0xD000093C /end MEASUREMENT
/begin MEASUREMENT GGLSF2ZA.B_lpenable "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x10 FORMAT "%13.11" ECU_ADDRESS 0xD000093C /end MEASUREMENT
/begin MEASUREMENT GGLSF2ZA.B_lpend "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x20 FORMAT "%13.11" ECU_ADDRESS 0xD000093C /end MEASUREMENT
/begin MEASUREMENT GGLSF2ZA.B_ribever "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x2 FORMAT "%13.11" ECU_ADDRESS 0xD000093C /end MEASUREMENT
/begin MEASUREMENT GGLSF2ZA.B_rin "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD0000938 /end MEASUREMENT
/begin MEASUREMENT GGLSF2ZA.B_rinoausr "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x4 FORMAT "%13.11" ECU_ADDRESS 0xD000093C /end MEASUREMENT
/begin MEASUREMENT GGLSF2ZA.B_ripu "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x40 FORMAT "%13.11" ECU_ADDRESS 0xD000093C /end MEASUREMENT
/begin MEASUREMENT GGLSF2ZA.B_ripuls "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x80 FORMAT "%13.11" ECU_ADDRESS 0xD000093C /end MEASUREMENT
/begin MEASUREMENT GGLSF2ZA.B_suerf "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD0000939 /end MEASUREMENT
/begin MEASUREMENT GGLSF2ZA.B_usbe "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD000093A /end MEASUREMENT
/begin MEASUREMENT GGLSF2ZA.B_uslp "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD000093B /end MEASUREMENT
/begin MEASUREMENT GGLSF2ZA.rin_w "" UWORD r_uw_q2 1 100 0.00 131070.0 FORMAT "%8.1" ECU_ADDRESS 0xD0000940 /end MEASUREMENT
/begin MEASUREMENT GGLSF2ZA.rinof_w "" UWORD r_uw_q2 1 100 0.00 131070.0 FORMAT "%8.1" ECU_ADDRESS 0xD0000942 /end MEASUREMENT
/begin MEASUREMENT GGLSF2ZA.rinofa_w "" UWORD r_uw_q2 1 100 0.00 131070.0 FORMAT "%8.1" ECU_ADDRESS 0xD0000944 /end MEASUREMENT
/begin MEASUREMENT GGLSF2ZA.sm "" UBYTE OneToOne 1 100 0.00 3.000 FORMAT "%5.3" ECU_ADDRESS 0xD0000946 /end MEASUREMENT
/begin MEASUREMENT GGLSF2ZA.us_w "" UWORD spg_uw_q0p00488 1 100 0.00 319.9951 FORMAT "%8.4" ECU_ADDRESS 0xD0000948 /end MEASUREMENT
/begin MEASUREMENT GGLSF2ZA.uslp_w "" UWORD spg_uw_q0p00488 1 100 0.00 319.9951 FORMAT "%8.4" ECU_ADDRESS 0xD000094A /end MEASUREMENT
/begin MEASUREMENT GGLSF2ZA.uslpdiff_w "" UWORD spg_uw_q0p00488 1 100 0.00 319.9951 FORMAT "%8.4" ECU_ADDRESS 0xD000094C /end MEASUREMENT
/begin MEASUREMENT GGLSF2ZA.usmb_w "" UWORD spg_uw_q0p00488 1 100 0.00 319.9951 FORMAT "%8.4" ECU_ADDRESS 0xD000094E /end MEASUREMENT
/begin MEASUREMENT GGLSF2ZA.usnerf_w "" UWORD spg_uw_q0p00488 1 100 0.00 319.9951 FORMAT "%8.4" ECU_ADDRESS 0xD0000950 /end MEASUREMENT
/begin MEASUREMENT GGLSF2ZA.usob_w "" UWORD spg_uw_q0p00488 1 100 0.00 319.9951 FORMAT "%8.4" ECU_ADDRESS 0xD0000952 /end MEASUREMENT
/begin MEASUREMENT GGLSF2ZA.zlp "" UBYTE dez 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0000956 /end MEASUREMENT
/begin MEASUREMENT GGLSF2ZA.zlpmax "" UBYTE dez 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0000957 /end MEASUREMENT
/begin MEASUREMENT GGLSF2ZA.ANZRIWZG_CTR.counter "" UBYTE dez 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0000958 /end MEASUREMENT
/begin MEASUREMENT GGLSF2ZA.RIN_DL.memory "" ULONG r_q3p0518Em5 1 100 0.00 131071.999969 FORMAT "%13.6" ECU_ADDRESS 0xD0000960 /end MEASUREMENT
/begin MEASUREMENT GGLSF2ZA.RIPULS_TE.timeCounter "" UBYTE t_q0p001 1 100 0.00 0.2550 FORMAT "%6.4" ECU_ADDRESS 0xD0000964 /end MEASUREMENT
/begin MEASUREMENT GGLSF2ZA.TRIAKT_TR.timeCounter "" UBYTE t_q0p1 1 100 0.00 25.50 FORMAT "%5.2" ECU_ADDRESS 0xD0000968 /end MEASUREMENT
/begin MEASUREMENT GGLSF2ZA.TUSBEL_TE.timeCounter "" UBYTE t_q0p01 1 100 0.00 2.550 FORMAT "%5.3" ECU_ADDRESS 0xD0000969 /end MEASUREMENT
/begin MEASUREMENT GGLSF2ZA.TUSRIBER_TONV.outbit "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD000096A /end MEASUREMENT
/begin MEASUREMENT GGLSF2ZA.TUSRIBER_TONV.time "" UBYTE t_q0p01 1 100 0.00 2.550 FORMAT "%5.3" ECU_ADDRESS 0xD000096B /end MEASUREMENT
/begin MEASUREMENT GGLSF2ZA.ZRIBER_CTR.counter "" UBYTE dez 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD000096C /end MEASUREMENT
/begin MEASUREMENT GGLSFZA.B_enrin "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD0000974 /end MEASUREMENT
/begin MEASUREMENT GGLSFZA.B_lpcalc "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x8 FORMAT "%13.11" ECU_ADDRESS 0xD0000974 /end MEASUREMENT
/begin MEASUREMENT GGLSFZA.B_lpenable "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x10 FORMAT "%13.11" ECU_ADDRESS 0xD0000974 /end MEASUREMENT
/begin MEASUREMENT GGLSFZA.B_lpend "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x20 FORMAT "%13.11" ECU_ADDRESS 0xD0000974 /end MEASUREMENT
/begin MEASUREMENT GGLSFZA.B_ribever "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x2 FORMAT "%13.11" ECU_ADDRESS 0xD0000974 /end MEASUREMENT
/begin MEASUREMENT GGLSFZA.B_rin "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD0000970 /end MEASUREMENT
/begin MEASUREMENT GGLSFZA.B_rinoausr "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x4 FORMAT "%13.11" ECU_ADDRESS 0xD0000974 /end MEASUREMENT
/begin MEASUREMENT GGLSFZA.B_ripu "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x40 FORMAT "%13.11" ECU_ADDRESS 0xD0000974 /end MEASUREMENT
/begin MEASUREMENT GGLSFZA.B_ripuls "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x80 FORMAT "%13.11" ECU_ADDRESS 0xD0000974 /end MEASUREMENT
/begin MEASUREMENT GGLSFZA.B_suerf "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD0000971 /end MEASUREMENT
/begin MEASUREMENT GGLSFZA.B_usbe "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD0000972 /end MEASUREMENT
/begin MEASUREMENT GGLSFZA.B_uslp "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD0000973 /end MEASUREMENT
/begin MEASUREMENT GGLSFZA.rin_w "" UWORD r_uw_q2 1 100 0.00 131070.0 FORMAT "%8.1" ECU_ADDRESS 0xD0000978 /end MEASUREMENT
/begin MEASUREMENT GGLSFZA.rinof_w "" UWORD r_uw_q2 1 100 0.00 131070.0 FORMAT "%8.1" ECU_ADDRESS 0xD000097A /end MEASUREMENT
/begin MEASUREMENT GGLSFZA.rinofa_w "" UWORD r_uw_q2 1 100 0.00 131070.0 FORMAT "%8.1" ECU_ADDRESS 0xD000097C /end MEASUREMENT
/begin MEASUREMENT GGLSFZA.sm "" UBYTE OneToOne 1 100 0.00 3.000 FORMAT "%5.3" ECU_ADDRESS 0xD000097E /end MEASUREMENT
/begin MEASUREMENT GGLSFZA.us_w "" UWORD spg_uw_q0p00488 1 100 0.00 319.9951 FORMAT "%8.4" ECU_ADDRESS 0xD0000980 /end MEASUREMENT
/begin MEASUREMENT GGLSFZA.uslp_w "" UWORD spg_uw_q0p00488 1 100 0.00 319.9951 FORMAT "%8.4" ECU_ADDRESS 0xD0000982 /end MEASUREMENT
/begin MEASUREMENT GGLSFZA.uslpdiff_w "" UWORD spg_uw_q0p00488 1 100 0.00 319.9951 FORMAT "%8.4" ECU_ADDRESS 0xD0000984 /end MEASUREMENT
/begin MEASUREMENT GGLSFZA.usmb_w "" UWORD spg_uw_q0p00488 1 100 0.00 319.9951 FORMAT "%8.4" ECU_ADDRESS 0xD0000986 /end MEASUREMENT
/begin MEASUREMENT GGLSFZA.usnerf_w "" UWORD spg_uw_q0p00488 1 100 0.00 319.9951 FORMAT "%8.4" ECU_ADDRESS 0xD0000988 /end MEASUREMENT
/begin MEASUREMENT GGLSFZA.usob_w "" UWORD spg_uw_q0p00488 1 100 0.00 319.9951 FORMAT "%8.4" ECU_ADDRESS 0xD000098A /end MEASUREMENT
/begin MEASUREMENT GGLSFZA.zlp "" UBYTE dez 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD000098E /end MEASUREMENT
/begin MEASUREMENT GGLSFZA.zlpmax "" UBYTE dez 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD000098F /end MEASUREMENT
/begin MEASUREMENT GGLSFZA.ANZRIWZG_CTR.counter "" UBYTE dez 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0000990 /end MEASUREMENT
/begin MEASUREMENT GGLSFZA.RIN_DL.memory "" ULONG r_q3p0518Em5 1 100 0.00 131071.999969 FORMAT "%13.6" ECU_ADDRESS 0xD0000998 /end MEASUREMENT
/begin MEASUREMENT GGLSFZA.RIPULS_TE.timeCounter "" UBYTE t_q0p001 1 100 0.00 0.2550 FORMAT "%6.4" ECU_ADDRESS 0xD000099C /end MEASUREMENT
/begin MEASUREMENT GGLSFZA.TRIAKT_TR.timeCounter "" UBYTE t_q0p1 1 100 0.00 25.50 FORMAT "%5.2" ECU_ADDRESS 0xD00009A0 /end MEASUREMENT
/begin MEASUREMENT GGLSFZA.TUSBEL_TE.timeCounter "" UBYTE t_q0p01 1 100 0.00 2.550 FORMAT "%5.3" ECU_ADDRESS 0xD00009A1 /end MEASUREMENT
/begin MEASUREMENT GGLSFZA.TUSRIBER_TONV.outbit "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD00009A2 /end MEASUREMENT
/begin MEASUREMENT GGLSFZA.TUSRIBER_TONV.time "" UBYTE t_q0p01 1 100 0.00 2.550 FORMAT "%5.3" ECU_ADDRESS 0xD00009A3 /end MEASUREMENT
/begin MEASUREMENT GGLSFZA.ZRIBER_CTR.counter "" UBYTE dez 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD00009A4 /end MEASUREMENT
/begin MEASUREMENT GGLSH2ZA.B_enrin "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD00009AC /end MEASUREMENT
/begin MEASUREMENT GGLSH2ZA.B_lpcalc "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x8 FORMAT "%13.11" ECU_ADDRESS 0xD00009AC /end MEASUREMENT
/begin MEASUREMENT GGLSH2ZA.B_lpenable "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x10 FORMAT "%13.11" ECU_ADDRESS 0xD00009AC /end MEASUREMENT
/begin MEASUREMENT GGLSH2ZA.B_lpend "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x20 FORMAT "%13.11" ECU_ADDRESS 0xD00009AC /end MEASUREMENT
/begin MEASUREMENT GGLSH2ZA.B_ribever "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x2 FORMAT "%13.11" ECU_ADDRESS 0xD00009AC /end MEASUREMENT
/begin MEASUREMENT GGLSH2ZA.B_rin "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD00009A8 /end MEASUREMENT
/begin MEASUREMENT GGLSH2ZA.B_rinoausr "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x4 FORMAT "%13.11" ECU_ADDRESS 0xD00009AC /end MEASUREMENT
/begin MEASUREMENT GGLSH2ZA.B_ripu "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x40 FORMAT "%13.11" ECU_ADDRESS 0xD00009AC /end MEASUREMENT
/begin MEASUREMENT GGLSH2ZA.B_ripuls "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x80 FORMAT "%13.11" ECU_ADDRESS 0xD00009AC /end MEASUREMENT
/begin MEASUREMENT GGLSH2ZA.B_suerf "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD00009A9 /end MEASUREMENT
/begin MEASUREMENT GGLSH2ZA.B_usbe "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD00009AA /end MEASUREMENT
/begin MEASUREMENT GGLSH2ZA.B_uslp "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD00009AB /end MEASUREMENT
/begin MEASUREMENT GGLSH2ZA.rin_w "" UWORD r_uw_q2 1 100 0.00 131070.0 FORMAT "%8.1" ECU_ADDRESS 0xD00009B0 /end MEASUREMENT
/begin MEASUREMENT GGLSH2ZA.rinof_w "" UWORD r_uw_q2 1 100 0.00 131070.0 FORMAT "%8.1" ECU_ADDRESS 0xD00009B2 /end MEASUREMENT
/begin MEASUREMENT GGLSH2ZA.rinofa_w "" UWORD r_uw_q2 1 100 0.00 131070.0 FORMAT "%8.1" ECU_ADDRESS 0xD00009B4 /end MEASUREMENT
/begin MEASUREMENT GGLSH2ZA.sm "" UBYTE OneToOne 1 100 0.00 3.000 FORMAT "%5.3" ECU_ADDRESS 0xD00009B6 /end MEASUREMENT
/begin MEASUREMENT GGLSH2ZA.us_w "" UWORD spg_uw_q0p00488 1 100 0.00 319.9951 FORMAT "%8.4" ECU_ADDRESS 0xD00009B8 /end MEASUREMENT
/begin MEASUREMENT GGLSH2ZA.uslp_w "" UWORD spg_uw_q0p00488 1 100 0.00 319.9951 FORMAT "%8.4" ECU_ADDRESS 0xD00009BA /end MEASUREMENT
/begin MEASUREMENT GGLSH2ZA.uslpdiff_w "" UWORD spg_uw_q0p00488 1 100 0.00 319.9951 FORMAT "%8.4" ECU_ADDRESS 0xD00009BC /end MEASUREMENT
/begin MEASUREMENT GGLSH2ZA.usmb_w "" UWORD spg_uw_q0p00488 1 100 0.00 319.9951 FORMAT "%8.4" ECU_ADDRESS 0xD00009BE /end MEASUREMENT
/begin MEASUREMENT GGLSH2ZA.usnerf_w "" UWORD spg_uw_q0p00488 1 100 0.00 319.9951 FORMAT "%8.4" ECU_ADDRESS 0xD00009C0 /end MEASUREMENT
/begin MEASUREMENT GGLSH2ZA.usob_w "" UWORD spg_uw_q0p00488 1 100 0.00 319.9951 FORMAT "%8.4" ECU_ADDRESS 0xD00009C2 /end MEASUREMENT
/begin MEASUREMENT GGLSH2ZA.zlp "" UBYTE dez 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD00009C6 /end MEASUREMENT
/begin MEASUREMENT GGLSH2ZA.zlpmax "" UBYTE dez 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD00009C7 /end MEASUREMENT
/begin MEASUREMENT GGLSH2ZA.ANZRIWZG_CTR.counter "" UBYTE dez 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD00009C8 /end MEASUREMENT
/begin MEASUREMENT GGLSH2ZA.RIN_DL.memory "" ULONG r_q3p0518Em5 1 100 0.00 131071.999969 FORMAT "%13.6" ECU_ADDRESS 0xD00009D0 /end MEASUREMENT
/begin MEASUREMENT GGLSH2ZA.RIPULS_TE.timeCounter "" UBYTE t_q0p001 1 100 0.00 0.2550 FORMAT "%6.4" ECU_ADDRESS 0xD00009D4 /end MEASUREMENT
/begin MEASUREMENT GGLSH2ZA.TRIAKT_TR.timeCounter "" UBYTE t_q0p1 1 100 0.00 25.50 FORMAT "%5.2" ECU_ADDRESS 0xD00009D8 /end MEASUREMENT
/begin MEASUREMENT GGLSH2ZA.TUSBEL_TE.timeCounter "" UBYTE t_q0p01 1 100 0.00 2.550 FORMAT "%5.3" ECU_ADDRESS 0xD00009D9 /end MEASUREMENT
/begin MEASUREMENT GGLSH2ZA.TUSRIBER_TONV.outbit "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD00009DA /end MEASUREMENT
/begin MEASUREMENT GGLSH2ZA.TUSRIBER_TONV.time "" UBYTE t_q0p01 1 100 0.00 2.550 FORMAT "%5.3" ECU_ADDRESS 0xD00009DB /end MEASUREMENT
/begin MEASUREMENT GGLSH2ZA.ZRIBER_CTR.counter "" UBYTE dez 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD00009DC /end MEASUREMENT
/begin MEASUREMENT GGLSHZA.B_enrin "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD00009E4 /end MEASUREMENT
/begin MEASUREMENT GGLSHZA.B_lpcalc "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x8 FORMAT "%13.11" ECU_ADDRESS 0xD00009E4 /end MEASUREMENT
/begin MEASUREMENT GGLSHZA.B_lpenable "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x10 FORMAT "%13.11" ECU_ADDRESS 0xD00009E4 /end MEASUREMENT
/begin MEASUREMENT GGLSHZA.B_lpend "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x20 FORMAT "%13.11" ECU_ADDRESS 0xD00009E4 /end MEASUREMENT
/begin MEASUREMENT GGLSHZA.B_ribever "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x2 FORMAT "%13.11" ECU_ADDRESS 0xD00009E4 /end MEASUREMENT
/begin MEASUREMENT GGLSHZA.B_rin "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD00009E0 /end MEASUREMENT
/begin MEASUREMENT GGLSHZA.B_rinoausr "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x4 FORMAT "%13.11" ECU_ADDRESS 0xD00009E4 /end MEASUREMENT
/begin MEASUREMENT GGLSHZA.B_ripu "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x40 FORMAT "%13.11" ECU_ADDRESS 0xD00009E4 /end MEASUREMENT
/begin MEASUREMENT GGLSHZA.B_ripuls "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x80 FORMAT "%13.11" ECU_ADDRESS 0xD00009E4 /end MEASUREMENT
/begin MEASUREMENT GGLSHZA.B_suerf "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD00009E1 /end MEASUREMENT
/begin MEASUREMENT GGLSHZA.B_usbe "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD00009E2 /end MEASUREMENT
/begin MEASUREMENT GGLSHZA.B_uslp "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD00009E3 /end MEASUREMENT
/begin MEASUREMENT GGLSHZA.rin_w "" UWORD r_uw_q2 1 100 0.00 131070.0 FORMAT "%8.1" ECU_ADDRESS 0xD00009E8 /end MEASUREMENT
/begin MEASUREMENT GGLSHZA.rinof_w "" UWORD r_uw_q2 1 100 0.00 131070.0 FORMAT "%8.1" ECU_ADDRESS 0xD00009EA /end MEASUREMENT
/begin MEASUREMENT GGLSHZA.rinofa_w "" UWORD r_uw_q2 1 100 0.00 131070.0 FORMAT "%8.1" ECU_ADDRESS 0xD00009EC /end MEASUREMENT
/begin MEASUREMENT GGLSHZA.sm "" UBYTE OneToOne 1 100 0.00 3.000 FORMAT "%5.3" ECU_ADDRESS 0xD00009EE /end MEASUREMENT
/begin MEASUREMENT GGLSHZA.us_w "" UWORD spg_uw_q0p00488 1 100 0.00 319.9951 FORMAT "%8.4" ECU_ADDRESS 0xD00009F0 /end MEASUREMENT
/begin MEASUREMENT GGLSHZA.uslp_w "" UWORD spg_uw_q0p00488 1 100 0.00 319.9951 FORMAT "%8.4" ECU_ADDRESS 0xD00009F2 /end MEASUREMENT
/begin MEASUREMENT GGLSHZA.uslpdiff_w "" UWORD spg_uw_q0p00488 1 100 0.00 319.9951 FORMAT "%8.4" ECU_ADDRESS 0xD00009F4 /end MEASUREMENT
/begin MEASUREMENT GGLSHZA.usmb_w "" UWORD spg_uw_q0p00488 1 100 0.00 319.9951 FORMAT "%8.4" ECU_ADDRESS 0xD00009F6 /end MEASUREMENT
/begin MEASUREMENT GGLSHZA.usnerf_w "" UWORD spg_uw_q0p00488 1 100 0.00 319.9951 FORMAT "%8.4" ECU_ADDRESS 0xD00009F8 /end MEASUREMENT
/begin MEASUREMENT GGLSHZA.usob_w "" UWORD spg_uw_q0p00488 1 100 0.00 319.9951 FORMAT "%8.4" ECU_ADDRESS 0xD00009FA /end MEASUREMENT
/begin MEASUREMENT GGLSHZA.zlp "" UBYTE dez 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD00009FE /end MEASUREMENT
/begin MEASUREMENT GGLSHZA.zlpmax "" UBYTE dez 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD00009FF /end MEASUREMENT
/begin MEASUREMENT GGLSHZA.ANZRIWZG_CTR.counter "" UBYTE dez 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0000A00 /end MEASUREMENT
/begin MEASUREMENT GGLSHZA.RIN_DL.memory "" ULONG r_q3p0518Em5 1 100 0.00 131071.999969 FORMAT "%13.6" ECU_ADDRESS 0xD0000A08 /end MEASUREMENT
/begin MEASUREMENT GGLSHZA.RIPULS_TE.timeCounter "" UBYTE t_q0p001 1 100 0.00 0.2550 FORMAT "%6.4" ECU_ADDRESS 0xD0000A0C /end MEASUREMENT
/begin MEASUREMENT GGLSHZA.TRIAKT_TR.timeCounter "" UBYTE t_q0p1 1 100 0.00 25.50 FORMAT "%5.2" ECU_ADDRESS 0xD0000A10 /end MEASUREMENT
/begin MEASUREMENT GGLSHZA.TUSBEL_TE.timeCounter "" UBYTE t_q0p01 1 100 0.00 2.550 FORMAT "%5.3" ECU_ADDRESS 0xD0000A11 /end MEASUREMENT
/begin MEASUREMENT GGLSHZA.TUSRIBER_TONV.outbit "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD0000A12 /end MEASUREMENT
/begin MEASUREMENT GGLSHZA.TUSRIBER_TONV.time "" UBYTE t_q0p01 1 100 0.00 2.550 FORMAT "%5.3" ECU_ADDRESS 0xD0000A13 /end MEASUREMENT
/begin MEASUREMENT GGLSHZA.ZRIBER_CTR.counter "" UBYTE dez 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0000A14 /end MEASUREMENT
/begin MEASUREMENT GGLSV2ZA.B_enrin "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD0000A1C /end MEASUREMENT
/begin MEASUREMENT GGLSV2ZA.B_lpcalc "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x8 FORMAT "%13.11" ECU_ADDRESS 0xD0000A1C /end MEASUREMENT
/begin MEASUREMENT GGLSV2ZA.B_lpenable "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x10 FORMAT "%13.11" ECU_ADDRESS 0xD0000A1C /end MEASUREMENT
/begin MEASUREMENT GGLSV2ZA.B_lpend "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x20 FORMAT "%13.11" ECU_ADDRESS 0xD0000A1C /end MEASUREMENT
/begin MEASUREMENT GGLSV2ZA.B_ribever "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x2 FORMAT "%13.11" ECU_ADDRESS 0xD0000A1C /end MEASUREMENT
/begin MEASUREMENT GGLSV2ZA.B_rin "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD0000A18 /end MEASUREMENT
/begin MEASUREMENT GGLSV2ZA.B_rinoausr "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x4 FORMAT "%13.11" ECU_ADDRESS 0xD0000A1C /end MEASUREMENT
/begin MEASUREMENT GGLSV2ZA.B_ripu "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x40 FORMAT "%13.11" ECU_ADDRESS 0xD0000A1C /end MEASUREMENT
/begin MEASUREMENT GGLSV2ZA.B_ripuls "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x80 FORMAT "%13.11" ECU_ADDRESS 0xD0000A1C /end MEASUREMENT
/begin MEASUREMENT GGLSV2ZA.B_suerf "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD0000A19 /end MEASUREMENT
/begin MEASUREMENT GGLSV2ZA.B_usbe "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD0000A1A /end MEASUREMENT
/begin MEASUREMENT GGLSV2ZA.B_uslp "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD0000A1B /end MEASUREMENT
/begin MEASUREMENT GGLSV2ZA.rin_w "" UWORD r_uw_q2 1 100 0.00 131070.0 FORMAT "%8.1" ECU_ADDRESS 0xD0000A20 /end MEASUREMENT
/begin MEASUREMENT GGLSV2ZA.rinof_w "" UWORD r_uw_q2 1 100 0.00 131070.0 FORMAT "%8.1" ECU_ADDRESS 0xD0000A22 /end MEASUREMENT
/begin MEASUREMENT GGLSV2ZA.rinofa_w "" UWORD r_uw_q2 1 100 0.00 131070.0 FORMAT "%8.1" ECU_ADDRESS 0xD0000A24 /end MEASUREMENT
/begin MEASUREMENT GGLSV2ZA.sm "" UBYTE OneToOne 1 100 0.00 3.000 FORMAT "%5.3" ECU_ADDRESS 0xD0000A26 /end MEASUREMENT
/begin MEASUREMENT GGLSV2ZA.us_w "" UWORD spg_uw_q0p00488 1 100 0.00 319.9951 FORMAT "%8.4" ECU_ADDRESS 0xD0000A28 /end MEASUREMENT
/begin MEASUREMENT GGLSV2ZA.uslp_w "" UWORD spg_uw_q0p00488 1 100 0.00 319.9951 FORMAT "%8.4" ECU_ADDRESS 0xD0000A2A /end MEASUREMENT
/begin MEASUREMENT GGLSV2ZA.uslpdiff_w "" UWORD spg_uw_q0p00488 1 100 0.00 319.9951 FORMAT "%8.4" ECU_ADDRESS 0xD0000A2C /end MEASUREMENT
/begin MEASUREMENT GGLSV2ZA.usmb_w "" UWORD spg_uw_q0p00488 1 100 0.00 319.9951 FORMAT "%8.4" ECU_ADDRESS 0xD0000A2E /end MEASUREMENT
/begin MEASUREMENT GGLSV2ZA.usnerf_w "" UWORD spg_uw_q0p00488 1 100 0.00 319.9951 FORMAT "%8.4" ECU_ADDRESS 0xD0000A30 /end MEASUREMENT
/begin MEASUREMENT GGLSV2ZA.usob_w "" UWORD spg_uw_q0p00488 1 100 0.00 319.9951 FORMAT "%8.4" ECU_ADDRESS 0xD0000A32 /end MEASUREMENT
/begin MEASUREMENT GGLSV2ZA.zlp "" UBYTE dez 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0000A36 /end MEASUREMENT
/begin MEASUREMENT GGLSV2ZA.zlpmax "" UBYTE dez 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0000A37 /end MEASUREMENT
/begin MEASUREMENT GGLSV2ZA.ANZRIWZG_CTR.counter "" UBYTE dez 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0000A38 /end MEASUREMENT
/begin MEASUREMENT GGLSV2ZA.RIN_DL.memory "" ULONG r_q3p0518Em5 1 100 0.00 131071.999969 FORMAT "%13.6" ECU_ADDRESS 0xD0000A40 /end MEASUREMENT
/begin MEASUREMENT GGLSV2ZA.RIPULS_TE.timeCounter "" UBYTE t_q0p001 1 100 0.00 0.2550 FORMAT "%6.4" ECU_ADDRESS 0xD0000A44 /end MEASUREMENT
/begin MEASUREMENT GGLSV2ZA.TRIAKT_TR.timeCounter "" UBYTE t_q0p1 1 100 0.00 25.50 FORMAT "%5.2" ECU_ADDRESS 0xD0000A48 /end MEASUREMENT
/begin MEASUREMENT GGLSV2ZA.TUSBEL_TE.timeCounter "" UBYTE t_q0p01 1 100 0.00 2.550 FORMAT "%5.3" ECU_ADDRESS 0xD0000A49 /end MEASUREMENT
/begin MEASUREMENT GGLSV2ZA.TUSRIBER_TONV.outbit "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD0000A4A /end MEASUREMENT
/begin MEASUREMENT GGLSV2ZA.TUSRIBER_TONV.time "" UBYTE t_q0p01 1 100 0.00 2.550 FORMAT "%5.3" ECU_ADDRESS 0xD0000A4B /end MEASUREMENT
/begin MEASUREMENT GGLSV2ZA.ZRIBER_CTR.counter "" UBYTE dez 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0000A4C /end MEASUREMENT
/begin MEASUREMENT GGLSVZA.B_enrin "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD0000A54 /end MEASUREMENT
/begin MEASUREMENT GGLSVZA.B_lpcalc "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x8 FORMAT "%13.11" ECU_ADDRESS 0xD0000A54 /end MEASUREMENT
/begin MEASUREMENT GGLSVZA.B_lpenable "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x10 FORMAT "%13.11" ECU_ADDRESS 0xD0000A54 /end MEASUREMENT
/begin MEASUREMENT GGLSVZA.B_lpend "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x20 FORMAT "%13.11" ECU_ADDRESS 0xD0000A54 /end MEASUREMENT
/begin MEASUREMENT GGLSVZA.B_ribever "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x2 FORMAT "%13.11" ECU_ADDRESS 0xD0000A54 /end MEASUREMENT
/begin MEASUREMENT GGLSVZA.B_rin "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD0000A50 /end MEASUREMENT
/begin MEASUREMENT GGLSVZA.B_rinoausr "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x4 FORMAT "%13.11" ECU_ADDRESS 0xD0000A54 /end MEASUREMENT
/begin MEASUREMENT GGLSVZA.B_ripu "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x40 FORMAT "%13.11" ECU_ADDRESS 0xD0000A54 /end MEASUREMENT
/begin MEASUREMENT GGLSVZA.B_ripuls "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x80 FORMAT "%13.11" ECU_ADDRESS 0xD0000A54 /end MEASUREMENT
/begin MEASUREMENT GGLSVZA.B_suerf "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD0000A51 /end MEASUREMENT
/begin MEASUREMENT GGLSVZA.B_usbe "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD0000A52 /end MEASUREMENT
/begin MEASUREMENT GGLSVZA.B_uslp "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD0000A53 /end MEASUREMENT
/begin MEASUREMENT GGLSVZA.rin_w "" UWORD r_uw_q2 1 100 0.00 131070.0 FORMAT "%8.1" ECU_ADDRESS 0xD0000A58 /end MEASUREMENT
/begin MEASUREMENT GGLSVZA.rinof_w "" UWORD r_uw_q2 1 100 0.00 131070.0 FORMAT "%8.1" ECU_ADDRESS 0xD0000A5A /end MEASUREMENT
/begin MEASUREMENT GGLSVZA.rinofa_w "" UWORD r_uw_q2 1 100 0.00 131070.0 FORMAT "%8.1" ECU_ADDRESS 0xD0000A5C /end MEASUREMENT
/begin MEASUREMENT GGLSVZA.sm "" UBYTE OneToOne 1 100 0.00 3.000 FORMAT "%5.3" ECU_ADDRESS 0xD0000A5E /end MEASUREMENT
/begin MEASUREMENT GGLSVZA.us_w "" UWORD spg_uw_q0p00488 1 100 0.00 319.9951 FORMAT "%8.4" ECU_ADDRESS 0xD0000A60 /end MEASUREMENT
/begin MEASUREMENT GGLSVZA.uslp_w "" UWORD spg_uw_q0p00488 1 100 0.00 319.9951 FORMAT "%8.4" ECU_ADDRESS 0xD0000A62 /end MEASUREMENT
/begin MEASUREMENT GGLSVZA.uslpdiff_w "" UWORD spg_uw_q0p00488 1 100 0.00 319.9951 FORMAT "%8.4" ECU_ADDRESS 0xD0000A64 /end MEASUREMENT
/begin MEASUREMENT GGLSVZA.usmb_w "" UWORD spg_uw_q0p00488 1 100 0.00 319.9951 FORMAT "%8.4" ECU_ADDRESS 0xD0000A66 /end MEASUREMENT
/begin MEASUREMENT GGLSVZA.usnerf_w "" UWORD spg_uw_q0p00488 1 100 0.00 319.9951 FORMAT "%8.4" ECU_ADDRESS 0xD0000A68 /end MEASUREMENT
/begin MEASUREMENT GGLSVZA.usob_w "" UWORD spg_uw_q0p00488 1 100 0.00 319.9951 FORMAT "%8.4" ECU_ADDRESS 0xD0000A6A /end MEASUREMENT
/begin MEASUREMENT GGLSVZA.zlp "" UBYTE dez 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0000A6E /end MEASUREMENT
/begin MEASUREMENT GGLSVZA.zlpmax "" UBYTE dez 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0000A6F /end MEASUREMENT
/begin MEASUREMENT GGLSVZA.ANZRIWZG_CTR.counter "" UBYTE dez 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0000A70 /end MEASUREMENT
/begin MEASUREMENT GGLSVZA.RIN_DL.memory "" ULONG r_q3p0518Em5 1 100 0.00 131071.999969 FORMAT "%13.6" ECU_ADDRESS 0xD0000A78 /end MEASUREMENT
/begin MEASUREMENT GGLSVZA.RIPULS_TE.timeCounter "" UBYTE t_q0p001 1 100 0.00 0.2550 FORMAT "%6.4" ECU_ADDRESS 0xD0000A7C /end MEASUREMENT
/begin MEASUREMENT GGLSVZA.TRIAKT_TR.timeCounter "" UBYTE t_q0p1 1 100 0.00 25.50 FORMAT "%5.2" ECU_ADDRESS 0xD0000A80 /end MEASUREMENT
/begin MEASUREMENT GGLSVZA.TUSBEL_TE.timeCounter "" UBYTE t_q0p01 1 100 0.00 2.550 FORMAT "%5.3" ECU_ADDRESS 0xD0000A81 /end MEASUREMENT
/begin MEASUREMENT GGLSVZA.TUSRIBER_TONV.outbit "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD0000A82 /end MEASUREMENT
/begin MEASUREMENT GGLSVZA.TUSRIBER_TONV.time "" UBYTE t_q0p01 1 100 0.00 2.550 FORMAT "%5.3" ECU_ADDRESS 0xD0000A83 /end MEASUREMENT
/begin MEASUREMENT GGLSVZA.ZRIBER_CTR.counter "" UBYTE dez 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0000A84 /end MEASUREMENT
/begin MEASUREMENT GlbDa_lTotDst "" SLONG Length 1 100 -2147483648.00 2147483647.00 FORMAT "%13.2" ECU_ADDRESS 0xD0001E30 /end MEASUREMENT
/begin MEASUREMENT HLSF.B_enhse "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD0000B18 /end MEASUREMENT
/begin MEASUREMENT HLSF.B_hsa "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD0000B19 /end MEASUREMENT
/begin MEASUREMENT HLSF.B_hsant "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x2 FORMAT "%13.11" ECU_ADDRESS 0xD0000B18 /end MEASUREMENT
/begin MEASUREMENT HLSF.B_hsgnctr "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x2 FORMAT "%13.11" ECU_ADDRESS 0xD0000B19 /end MEASUREMENT
/begin MEASUREMENT HLSF.B_redhs "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x4 FORMAT "%13.11" ECU_ADDRESS 0xD0000B19 /end MEASUREMENT
/begin MEASUREMENT HLSF.B_shehs "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x8 FORMAT "%13.11" ECU_ADDRESS 0xD0000B19 /end MEASUREMENT
/begin MEASUREMENT HLSF.fedk "" UBYTE fak_q0p01 1 100 0.00 2.550 FORMAT "%5.3" ECU_ADDRESS 0xD0000B1A /end MEASUREMENT
/begin MEASUREMENT HLSF.phlsn "" UBYTE fak_q0p01 1 100 0.00 2.550 FORMAT "%5.3" ECU_ADDRESS 0xD0000B1B /end MEASUREMENT
/begin MEASUREMENT HLSF.tasohf_w "" UWORD temp_q0p0234_o273 1 100 -273.1500 1262.827 FORMAT "%8.3" ECU_ADDRESS 0xD0000B1C /end MEASUREMENT
/begin MEASUREMENT HLSF.tedub "" UBYTE t_q0p002 1 100 0.00 0.5100 ECU_ADDRESS 0xD0000B1E /end MEASUREMENT
/begin MEASUREMENT HLSF.thmax_w "" UWORD t_q0p1 1 100 0.00 6553.500 FORMAT "%8.3" ECU_ADDRESS 0xD0000B20 /end MEASUREMENT
/begin MEASUREMENT HLSF.tshehs_w "" UWORD t_q0p1 1 100 0.00 6553.500 FORMAT "%8.3" ECU_ADDRESS 0xD0000B22 /end MEASUREMENT
/begin MEASUREMENT HLSF.uhssol_w "" UWORD spg_q0p00039 1 100 0.00 25.59961 FORMAT "%8.5" ECU_ADDRESS 0xD0000B24 /end MEASUREMENT
/begin MEASUREMENT HLSF.uhsst_w "" UWORD spg_q0p00039 1 100 0.00 25.59961 FORMAT "%8.5" ECU_ADDRESS 0xD0000B26 /end MEASUREMENT
/begin MEASUREMENT HLSF.uhsta_w "" UWORD spg_q0p00039 1 100 0.00 25.59961 FORMAT "%8.5" ECU_ADDRESS 0xD0000B28 /end MEASUREMENT
/begin MEASUREMENT HLSF.uhsxf_w "" UWORD spg_q0p00039 1 100 0.00 25.59961 FORMAT "%8.5" ECU_ADDRESS 0xD0000B2A /end MEASUREMENT
/begin MEASUREMENT HLSF2.B_enhse "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD0000B44 /end MEASUREMENT
/begin MEASUREMENT HLSF2.B_hsa "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD0000B45 /end MEASUREMENT
/begin MEASUREMENT HLSF2.B_hsant "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x2 FORMAT "%13.11" ECU_ADDRESS 0xD0000B44 /end MEASUREMENT
/begin MEASUREMENT HLSF2.B_hsgnctr "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x2 FORMAT "%13.11" ECU_ADDRESS 0xD0000B45 /end MEASUREMENT
/begin MEASUREMENT HLSF2.B_redhs "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x4 FORMAT "%13.11" ECU_ADDRESS 0xD0000B45 /end MEASUREMENT
/begin MEASUREMENT HLSF2.B_shehs "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x8 FORMAT "%13.11" ECU_ADDRESS 0xD0000B45 /end MEASUREMENT
/begin MEASUREMENT HLSF2.fedk "" UBYTE fak_q0p01 1 100 0.00 2.550 FORMAT "%5.3" ECU_ADDRESS 0xD0000B46 /end MEASUREMENT
/begin MEASUREMENT HLSF2.phlsn "" UBYTE fak_q0p01 1 100 0.00 2.550 FORMAT "%5.3" ECU_ADDRESS 0xD0000B47 /end MEASUREMENT
/begin MEASUREMENT HLSF2.tasohf_w "" UWORD temp_q0p0234_o273 1 100 -273.1500 1262.827 FORMAT "%8.3" ECU_ADDRESS 0xD0000B48 /end MEASUREMENT
/begin MEASUREMENT HLSF2.tedub "" UBYTE t_q0p002 1 100 0.00 0.5100 ECU_ADDRESS 0xD0000B4A /end MEASUREMENT
/begin MEASUREMENT HLSF2.thmax_w "" UWORD t_q0p1 1 100 0.00 6553.500 FORMAT "%8.3" ECU_ADDRESS 0xD0000B4C /end MEASUREMENT
/begin MEASUREMENT HLSF2.tshehs_w "" UWORD t_q0p1 1 100 0.00 6553.500 FORMAT "%8.3" ECU_ADDRESS 0xD0000B4E /end MEASUREMENT
/begin MEASUREMENT HLSF2.uhssol_w "" UWORD spg_q0p00039 1 100 0.00 25.59961 FORMAT "%8.5" ECU_ADDRESS 0xD0000B50 /end MEASUREMENT
/begin MEASUREMENT HLSF2.uhsst_w "" UWORD spg_q0p00039 1 100 0.00 25.59961 FORMAT "%8.5" ECU_ADDRESS 0xD0000B52 /end MEASUREMENT
/begin MEASUREMENT HLSF2.uhsta_w "" UWORD spg_q0p00039 1 100 0.00 25.59961 FORMAT "%8.5" ECU_ADDRESS 0xD0000B54 /end MEASUREMENT
/begin MEASUREMENT HLSF2.uhsxf_w "" UWORD spg_q0p00039 1 100 0.00 25.59961 FORMAT "%8.5" ECU_ADDRESS 0xD0000B56 /end MEASUREMENT
/begin MEASUREMENT HLSFCYCLE.B_out "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD0000AE4 /end MEASUREMENT
/begin MEASUREMENT HLSH.B_enhse "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD0000B70 /end MEASUREMENT
/begin MEASUREMENT HLSH.B_hsa "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD0000B71 /end MEASUREMENT
/begin MEASUREMENT HLSH.B_hsant "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x2 FORMAT "%13.11" ECU_ADDRESS 0xD0000B70 /end MEASUREMENT
/begin MEASUREMENT HLSH.B_hsgnctr "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x2 FORMAT "%13.11" ECU_ADDRESS 0xD0000B71 /end MEASUREMENT
/begin MEASUREMENT HLSH.B_redhs "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x4 FORMAT "%13.11" ECU_ADDRESS 0xD0000B71 /end MEASUREMENT
/begin MEASUREMENT HLSH.B_shehs "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x8 FORMAT "%13.11" ECU_ADDRESS 0xD0000B71 /end MEASUREMENT
/begin MEASUREMENT HLSH.fedk "" UBYTE fak_q0p01 1 100 0.00 2.550 FORMAT "%5.3" ECU_ADDRESS 0xD0000B72 /end MEASUREMENT
/begin MEASUREMENT HLSH.phlsn "" UBYTE fak_q0p01 1 100 0.00 2.550 FORMAT "%5.3" ECU_ADDRESS 0xD0000B73 /end MEASUREMENT
/begin MEASUREMENT HLSH.tasohf_w "" UWORD temp_q0p0234_o273 1 100 -273.1500 1262.827 FORMAT "%8.3" ECU_ADDRESS 0xD0000B74 /end MEASUREMENT
/begin MEASUREMENT HLSH.tedub "" UBYTE t_q0p002 1 100 0.00 0.5100 ECU_ADDRESS 0xD0000B76 /end MEASUREMENT
/begin MEASUREMENT HLSH.thmax_w "" UWORD t_q0p1 1 100 0.00 6553.500 FORMAT "%8.3" ECU_ADDRESS 0xD0000B78 /end MEASUREMENT
/begin MEASUREMENT HLSH.tshehs_w "" UWORD t_q0p1 1 100 0.00 6553.500 FORMAT "%8.3" ECU_ADDRESS 0xD0000B7A /end MEASUREMENT
/begin MEASUREMENT HLSH.uhssol_w "" UWORD spg_q0p00039 1 100 0.00 25.59961 FORMAT "%8.5" ECU_ADDRESS 0xD0000B7C /end MEASUREMENT
/begin MEASUREMENT HLSH.uhsst_w "" UWORD spg_q0p00039 1 100 0.00 25.59961 FORMAT "%8.5" ECU_ADDRESS 0xD0000B7E /end MEASUREMENT
/begin MEASUREMENT HLSH.uhsta_w "" UWORD spg_q0p00039 1 100 0.00 25.59961 FORMAT "%8.5" ECU_ADDRESS 0xD0000B80 /end MEASUREMENT
/begin MEASUREMENT HLSH.uhsxf_w "" UWORD spg_q0p00039 1 100 0.00 25.59961 FORMAT "%8.5" ECU_ADDRESS 0xD0000B82 /end MEASUREMENT
/begin MEASUREMENT HLSH2.B_enhse "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD0000B9C /end MEASUREMENT
/begin MEASUREMENT HLSH2.B_hsa "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD0000B9D /end MEASUREMENT
/begin MEASUREMENT HLSH2.B_hsant "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x2 FORMAT "%13.11" ECU_ADDRESS 0xD0000B9C /end MEASUREMENT
/begin MEASUREMENT HLSH2.B_hsgnctr "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x2 FORMAT "%13.11" ECU_ADDRESS 0xD0000B9D /end MEASUREMENT
/begin MEASUREMENT HLSH2.B_redhs "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x4 FORMAT "%13.11" ECU_ADDRESS 0xD0000B9D /end MEASUREMENT
/begin MEASUREMENT HLSH2.B_shehs "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x8 FORMAT "%13.11" ECU_ADDRESS 0xD0000B9D /end MEASUREMENT
/begin MEASUREMENT HLSH2.fedk "" UBYTE fak_q0p01 1 100 0.00 2.550 FORMAT "%5.3" ECU_ADDRESS 0xD0000B9E /end MEASUREMENT
/begin MEASUREMENT HLSH2.phlsn "" UBYTE fak_q0p01 1 100 0.00 2.550 FORMAT "%5.3" ECU_ADDRESS 0xD0000B9F /end MEASUREMENT
/begin MEASUREMENT HLSH2.tasohf_w "" UWORD temp_q0p0234_o273 1 100 -273.1500 1262.827 FORMAT "%8.3" ECU_ADDRESS 0xD0000BA0 /end MEASUREMENT
/begin MEASUREMENT HLSH2.tedub "" UBYTE t_q0p002 1 100 0.00 0.5100 ECU_ADDRESS 0xD0000BA2 /end MEASUREMENT
/begin MEASUREMENT HLSH2.thmax_w "" UWORD t_q0p1 1 100 0.00 6553.500 FORMAT "%8.3" ECU_ADDRESS 0xD0000BA4 /end MEASUREMENT
/begin MEASUREMENT HLSH2.tshehs_w "" UWORD t_q0p1 1 100 0.00 6553.500 FORMAT "%8.3" ECU_ADDRESS 0xD0000BA6 /end MEASUREMENT
/begin MEASUREMENT HLSH2.uhssol_w "" UWORD spg_q0p00039 1 100 0.00 25.59961 FORMAT "%8.5" ECU_ADDRESS 0xD0000BA8 /end MEASUREMENT
/begin MEASUREMENT HLSH2.uhsst_w "" UWORD spg_q0p00039 1 100 0.00 25.59961 FORMAT "%8.5" ECU_ADDRESS 0xD0000BAA /end MEASUREMENT
/begin MEASUREMENT HLSH2.uhsta_w "" UWORD spg_q0p00039 1 100 0.00 25.59961 FORMAT "%8.5" ECU_ADDRESS 0xD0000BAC /end MEASUREMENT
/begin MEASUREMENT HLSH2.uhsxf_w "" UWORD spg_q0p00039 1 100 0.00 25.59961 FORMAT "%8.5" ECU_ADDRESS 0xD0000BAE /end MEASUREMENT
/begin MEASUREMENT HLSHCYCLE.B_out "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD0000AEA /end MEASUREMENT
/begin MEASUREMENT HLSV.B_enhse "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD0000BC8 /end MEASUREMENT
/begin MEASUREMENT HLSV.B_hsa "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD0000BC9 /end MEASUREMENT
/begin MEASUREMENT HLSV.B_hsant "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x2 FORMAT "%13.11" ECU_ADDRESS 0xD0000BC8 /end MEASUREMENT
/begin MEASUREMENT HLSV.B_hsgnctr "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x2 FORMAT "%13.11" ECU_ADDRESS 0xD0000BC9 /end MEASUREMENT
/begin MEASUREMENT HLSV.B_redhs "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x4 FORMAT "%13.11" ECU_ADDRESS 0xD0000BC9 /end MEASUREMENT
/begin MEASUREMENT HLSV.B_shehs "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x8 FORMAT "%13.11" ECU_ADDRESS 0xD0000BC9 /end MEASUREMENT
/begin MEASUREMENT HLSV.fedk "" UBYTE fak_q0p01 1 100 0.00 2.550 FORMAT "%5.3" ECU_ADDRESS 0xD0000BCA /end MEASUREMENT
/begin MEASUREMENT HLSV.phlsn "" UBYTE fak_q0p01 1 100 0.00 2.550 FORMAT "%5.3" ECU_ADDRESS 0xD0000BCB /end MEASUREMENT
/begin MEASUREMENT HLSV.tasohf_w "" UWORD temp_q0p0234_o273 1 100 -273.1500 1262.827 FORMAT "%8.3" ECU_ADDRESS 0xD0000BCC /end MEASUREMENT
/begin MEASUREMENT HLSV.tedub "" UBYTE t_q0p002 1 100 0.00 0.5100 ECU_ADDRESS 0xD0000BCE /end MEASUREMENT
/begin MEASUREMENT HLSV.thmax_w "" UWORD t_q0p1 1 100 0.00 6553.500 FORMAT "%8.3" ECU_ADDRESS 0xD0000BD0 /end MEASUREMENT
/begin MEASUREMENT HLSV.tshehs_w "" UWORD t_q0p1 1 100 0.00 6553.500 FORMAT "%8.3" ECU_ADDRESS 0xD0000BD2 /end MEASUREMENT
/begin MEASUREMENT HLSV.uhssol_w "" UWORD spg_q0p00039 1 100 0.00 25.59961 FORMAT "%8.5" ECU_ADDRESS 0xD0000BD4 /end MEASUREMENT
/begin MEASUREMENT HLSV.uhsst_w "" UWORD spg_q0p00039 1 100 0.00 25.59961 FORMAT "%8.5" ECU_ADDRESS 0xD0000BD6 /end MEASUREMENT
/begin MEASUREMENT HLSV.uhsta_w "" UWORD spg_q0p00039 1 100 0.00 25.59961 FORMAT "%8.5" ECU_ADDRESS 0xD0000BD8 /end MEASUREMENT
/begin MEASUREMENT HLSV.uhsxf_w "" UWORD spg_q0p00039 1 100 0.00 25.59961 FORMAT "%8.5" ECU_ADDRESS 0xD0000BDA /end MEASUREMENT
/begin MEASUREMENT HLSV2.B_enhse "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD0000BF4 /end MEASUREMENT
/begin MEASUREMENT HLSV2.B_hsa "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD0000BF5 /end MEASUREMENT
/begin MEASUREMENT HLSV2.B_hsant "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x2 FORMAT "%13.11" ECU_ADDRESS 0xD0000BF4 /end MEASUREMENT
/begin MEASUREMENT HLSV2.B_hsgnctr "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x2 FORMAT "%13.11" ECU_ADDRESS 0xD0000BF5 /end MEASUREMENT
/begin MEASUREMENT HLSV2.B_redhs "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x4 FORMAT "%13.11" ECU_ADDRESS 0xD0000BF5 /end MEASUREMENT
/begin MEASUREMENT HLSV2.B_shehs "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x8 FORMAT "%13.11" ECU_ADDRESS 0xD0000BF5 /end MEASUREMENT
/begin MEASUREMENT HLSV2.fedk "" UBYTE fak_q0p01 1 100 0.00 2.550 FORMAT "%5.3" ECU_ADDRESS 0xD0000BF6 /end MEASUREMENT
/begin MEASUREMENT HLSV2.phlsn "" UBYTE fak_q0p01 1 100 0.00 2.550 FORMAT "%5.3" ECU_ADDRESS 0xD0000BF7 /end MEASUREMENT
/begin MEASUREMENT HLSV2.tasohf_w "" UWORD temp_q0p0234_o273 1 100 -273.1500 1262.827 FORMAT "%8.3" ECU_ADDRESS 0xD0000BF8 /end MEASUREMENT
/begin MEASUREMENT HLSV2.tedub "" UBYTE t_q0p002 1 100 0.00 0.5100 ECU_ADDRESS 0xD0000BFA /end MEASUREMENT
/begin MEASUREMENT HLSV2.thmax_w "" UWORD t_q0p1 1 100 0.00 6553.500 FORMAT "%8.3" ECU_ADDRESS 0xD0000BFC /end MEASUREMENT
/begin MEASUREMENT HLSV2.tshehs_w "" UWORD t_q0p1 1 100 0.00 6553.500 FORMAT "%8.3" ECU_ADDRESS 0xD0000BFE /end MEASUREMENT
/begin MEASUREMENT HLSV2.uhssol_w "" UWORD spg_q0p00039 1 100 0.00 25.59961 FORMAT "%8.5" ECU_ADDRESS 0xD0000C00 /end MEASUREMENT
/begin MEASUREMENT HLSV2.uhsst_w "" UWORD spg_q0p00039 1 100 0.00 25.59961 FORMAT "%8.5" ECU_ADDRESS 0xD0000C02 /end MEASUREMENT
/begin MEASUREMENT HLSV2.uhsta_w "" UWORD spg_q0p00039 1 100 0.00 25.59961 FORMAT "%8.5" ECU_ADDRESS 0xD0000C04 /end MEASUREMENT
/begin MEASUREMENT HLSV2.uhsxf_w "" UWORD spg_q0p00039 1 100 0.00 25.59961 FORMAT "%8.5" ECU_ADDRESS 0xD0000C06 /end MEASUREMENT
/begin MEASUREMENT HLSVCYCLE.B_out "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD0000AF0 /end MEASUREMENT
/begin MEASUREMENT I14229CC_stRxEnable "" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD000013A /end MEASUREMENT
/begin MEASUREMENT I15031_FILLSIG1 "" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD00004F4 /end MEASUREMENT
/begin MEASUREMENT I15031_FILLSIG2 "" UWORD OneToOne 1 100 0.00 65535.00 FORMAT "%8.2" ECU_ADDRESS 0xD00000BC /end MEASUREMENT
/begin MEASUREMENT I15031_FILLSIG4 "" ULONG OneToOne 1 100 0.00 4294967295.00 FORMAT "%13.2" ECU_ADDRESS 0xD0001E40 /end MEASUREMENT
/begin MEASUREMENT I15031_PID1C "" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD00004F5 /end MEASUREMENT
/begin MEASUREMENT I15031_PID4FA "" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD00004F6 /end MEASUREMENT
/begin MEASUREMENT I15031_PID4FB "" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD00004F7 /end MEASUREMENT
/begin MEASUREMENT I15031_PID4FC "" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD00004F8 /end MEASUREMENT
/begin MEASUREMENT I15031_PID4FD "" UBYTE OneToTenCarb 1 100 0.00 2550. FORMAT "%5.0" ECU_ADDRESS 0xD00004F9 /end MEASUREMENT
/begin MEASUREMENT I15031_PID50A "" UBYTE OneToTenCarb 1 100 0.00 2550. FORMAT "%5.0" ECU_ADDRESS 0xD00004FA /end MEASUREMENT
/begin MEASUREMENT I15031_PID50B "" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD00004FB /end MEASUREMENT
/begin MEASUREMENT I15031_PID50C "" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD00004FC /end MEASUREMENT
/begin MEASUREMENT I15031_PID50D "" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD00004FD /end MEASUREMENT
/begin MEASUREMENT I15031_PID5F "" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD00004FE /end MEASUREMENT
/begin MEASUREMENT IgnClPs_bDiagEna "Diagnosis Enable Bit" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x20 FORMAT "%13.11" ECU_ADDRESS 0xD0001918 /end MEASUREMENT
/begin MEASUREMENT Igndd_nrIgnCir "Number of ignition circuits" UBYTE dez 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD00004FF /end MEASUREMENT
/begin MEASUREMENT Igndd_nrTypOfCl "Type of Coil" UBYTE dez 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD00017D6 /end MEASUREMENT
/begin MEASUREMENT Igndd_stFolwUpSprk_b "State of Follow up Spark" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD0000518 /end MEASUREMENT
/begin MEASUREMENT imlna2_w "" UWORD m_q2p777Em5_kg 1 100 0.00 1.820417 FORMAT "%8.6" ECU_ADDRESS 0xD0000C84 /end MEASUREMENT
/begin MEASUREMENT imlna_w "" UWORD m_q2p777Em5_kg 1 100 0.00 1.820417 FORMAT "%8.6" ECU_ADDRESS 0xD0000C86 /end MEASUREMENT
/begin MEASUREMENT injdd_InjTypeFuelMode "Type of injection system" UBYTE injdd_InjTypeFuelMode_State_t 1 100 0.00 1.00000000000 FORMAT "%13.11" ECU_ADDRESS 0xD000171E /end MEASUREMENT
/begin MEASUREMENT injmode_l "injection mode" ULONG dez 1 100 0.00 4294967295.00 FORMAT "%13.2" ARRAY_SIZE 8 ECU_ADDRESS 0xD0001E58 /end MEASUREMENT
/begin MEASUREMENT injvlvps_enaerr_b "" UBYTE dez 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0001826 /end MEASUREMENT
/begin MEASUREMENT injvlvps_verwerf1_b "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x10 FORMAT "%13.11" ECU_ADDRESS 0xD0001824 /end MEASUREMENT
/begin MEASUREMENT iproh_w_flex "" SWORD i_q1_uA 1 100 -32768.00 32767.00 FORMAT "%8.2" ARRAY_SIZE 2 ECU_ADDRESS 0xD00000A6 /end MEASUREMENT
/begin MEASUREMENT KnDet_actvChnMask "" UBYTE dez 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0001836 /end MEASUREMENT
/begin MEASUREMENT KnDet_bDiaDeb "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x20 FORMAT "%13.11" ECU_ADDRESS 0xD0001933 /end MEASUREMENT
/begin MEASUREMENT KnDet_bEnaSigEval "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD0001900 /end MEASUREMENT
/begin MEASUREMENT KnDet_bNewEval "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x80 FORMAT "%13.11" ECU_ADDRESS 0xD000190D /end MEASUREMENT
/begin MEASUREMENT KnDet_bStMeasWin "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x80 FORMAT "%13.11" ECU_ADDRESS 0xD0001916 /end MEASUREMENT
/begin MEASUREMENT KnDet_ctCyl "cylinder counter KnDet" UBYTE dez 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0001879 /end MEASUREMENT
/begin MEASUREMENT KnDet_ctDia "" UBYTE dez 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD000183A /end MEASUREMENT
/begin MEASUREMENT KnDet_ctIntegRsltInvld "counter integration results not valid" UBYTE dez 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD000183B /end MEASUREMENT
/begin MEASUREMENT KnDet_DebDiagVal1 "" UBYTE dez 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0001840 /end MEASUREMENT
/begin MEASUREMENT KnDet_DebDiagVal2 "" UBYTE dez 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0001841 /end MEASUREMENT
/begin MEASUREMENT KnDet_DiaRes "" UBYTE dez 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0001842 /end MEASUREMENT
/begin MEASUREMENT KnDet_HwDiaMode "" UBYTE dez 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0001837 /end MEASUREMENT
/begin MEASUREMENT KnDet_IntegWinEnd "integrator value at the end of the measuring window" ULONG dez 1 100 0.00 4294967295.00 FORMAT "%13.2" ARRAY_SIZE 1 ECU_ADDRESS 0xD0001CAC /end MEASUREMENT
/begin MEASUREMENT KnDet_numFltNew "" UWORD dez 1 100 0.00 65535.00 FORMAT "%8.2" ECU_ADDRESS 0xD0001626 /end MEASUREMENT
/begin MEASUREMENT KnDet_numSensDia "" UWORD dez 1 100 0.00 65535.00 FORMAT "%8.2" ECU_ADDRESS 0xD0001628 /end MEASUREMENT
/begin MEASUREMENT KnDet_numValMeasWin "" ULONG dez 1 100 0.00 4294967295.00 FORMAT "%13.2" ECU_ADDRESS 0xD0001CB4 /end MEASUREMENT
/begin MEASUREMENT KnDet_numValMeasWinEst "" UWORD dez 1 100 0.00 65535.00 FORMAT "%8.2" ECU_ADDRESS 0xD000161C /end MEASUREMENT
/begin MEASUREMENT KnDet_numValMeasWinTmp "" UWORD dez 1 100 0.00 65535.00 FORMAT "%8.2" ECU_ADDRESS 0xD000161E /end MEASUREMENT
/begin MEASUREMENT KnDet_phiMeasWinBgn "" SWORD kw_sw_q0p0219 1 100 -720.0000 719.9780 FORMAT "%8.4" ECU_ADDRESS 0xD0001620 /end MEASUREMENT
/begin MEASUREMENT KnDet_phiMeasWinLngth "" SWORD kw_sw_q0p0219 1 100 -720.0000 719.9780 FORMAT "%8.4" ECU_ADDRESS 0xD0001622 /end MEASUREMENT
/begin MEASUREMENT KnDet_phiMeasWinLngthOld "" SWORD kw_sw_q0p0219 1 100 -720.0000 719.9780 FORMAT "%8.4" ECU_ADDRESS 0xD0001624 /end MEASUREMENT
/begin MEASUREMENT KnDet_ReqSigEvalMode "" UBYTE dez 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD000183C /end MEASUREMENT
/begin MEASUREMENT KnDet_RlsChkMeasWin "" UBYTE dez 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD000183D /end MEASUREMENT
/begin MEASUREMENT KnDet_SensMode "" UBYTE dez 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD000183E /end MEASUREMENT
/begin MEASUREMENT KnDet_stDiaCtl "" UBYTE dez 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD000183F /end MEASUREMENT
/begin MEASUREMENT KnDet_stGetDigRawVal "" ULONG dez 1 100 0.00 4294967295.00 FORMAT "%13.2" ECU_ADDRESS 0xD0001CA8 /end MEASUREMENT
/begin MEASUREMENT KnDet_stMeasWin "" UBYTE dez 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0001838 /end MEASUREMENT
/begin MEASUREMENT KnDet_stOfsClb "" UBYTE dez 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0001839 /end MEASUREMENT
/begin MEASUREMENT KnDet_stSigEval "status Complex Driver KnDet current combustion" UBYTE dez 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0001843 /end MEASUREMENT
/begin MEASUREMENT KnDet_stSigEvalCurrCmb "" ULONG dez 1 100 0.00 4294967295.00 FORMAT "%13.2" ECU_ADDRESS 0xD0001CB0 /end MEASUREMENT
/begin MEASUREMENT KnDet_vNewIntegDia "" SWORD spg_sw_q0p0001 1 100 -3.300000 3.299899 FORMAT "%8.6" ECU_ADDRESS 0xD000162C /end MEASUREMENT
/begin MEASUREMENT KnDet_vNewIntegWinEnd "" ULONG dez 1 100 0.00 4294967295.00 FORMAT "%13.2" ARRAY_SIZE 1 ECU_ADDRESS 0xD0001CB8 /end MEASUREMENT
/begin MEASUREMENT KnDet_vValDia "" SWORD spg_sw_q0p0001 1 100 -3.300000 3.299899 FORMAT "%8.6" ECU_ADDRESS 0xD000162A /end MEASUREMENT
/begin MEASUREMENT ksnew "knock sensor number next combustion" UBYTE dez 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD000185B /end MEASUREMENT
/begin MEASUREMENT lamocip2_w "Air/fuel ratio request for check LSU open-circuit at IP, bank 2" UWORD fak_uw_b16 1 100 0.00 15.99976 FORMAT "%8.5" ECU_ADDRESS 0xD0000D54 /end MEASUREMENT
/begin MEASUREMENT lamocip_w "Air/fuel ratio request for check LSU open-circuit at IP" UWORD fak_uw_b16 1 100 0.00 15.99976 FORMAT "%8.5" ECU_ADDRESS 0xD0000D56 /end MEASUREMENT
/begin MEASUREMENT lamsonb_w_flex "" UWORD fak_uw_b16 1 100 0.00 15.99976 FORMAT "%8.5" ARRAY_SIZE 2 ECU_ADDRESS 0xD00000C0 /end MEASUREMENT
/begin MEASUREMENT lamsoni2_w "Lambda actual value" UWORD fak_q0p000244 1 100 0.00 15.99976 FORMAT "%8.5" ECU_ADDRESS 0xD000156C /end MEASUREMENT
/begin MEASUREMENT lamsoni_w "Lambda actual value" UWORD fak_q0p000244 1 100 0.00 15.99976 FORMAT "%8.5" ECU_ADDRESS 0xD000156E /end MEASUREMENT
/begin MEASUREMENT lastzyl "" UBYTE dez 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD000187E /end MEASUREMENT
/begin MEASUREMENT LSU_resRiUR "" SWORD Resist 1 100 -3276.800 3276.700 FORMAT "%8.3" ARRAY_SIZE 2 ECU_ADDRESS 0xD0000094 /end MEASUREMENT
/begin MEASUREMENT LSU_rLam "" SWORD lambda 1 100 -32.76800 32.76700 FORMAT "%8.5" ARRAY_SIZE 2 ECU_ADDRESS 0xD000008A /end MEASUREMENT
/begin MEASUREMENT LSU_rLamRec "" SWORD lambdaRecVal 1 100 -32.76800 32.76700 FORMAT "%8.5" ARRAY_SIZE 2 ECU_ADDRESS 0xD0000086 /end MEASUREMENT
/begin MEASUREMENT LSU_rO2ActUA "" SWORD O2 1 100 -0.3276800 0.3276700 FORMAT "%9.7" ARRAY_SIZE 2 ECU_ADDRESS 0xD0000090 /end MEASUREMENT
/begin MEASUREMENT LSU_rO2ActUA2 "" SWORD O2 1 100 -0.3276800 0.3276700 FORMAT "%9.7" ECU_ADDRESS 0xD000008E /end MEASUREMENT
/begin MEASUREMENT LSU_tRiUR "" SWORD Temp_Cels 1 100 -3549.940 3003.560 FORMAT "%8.3" ARRAY_SIZE 2 ECU_ADDRESS 0xD0000098 /end MEASUREMENT
/begin MEASUREMENT LSU_uRawAdcUA1_mp "" SWORD Volt 1 100 -6553.600 6553.400 FORMAT "%8.3" ECU_ADDRESS 0xD0017D2E /end MEASUREMENT
/begin MEASUREMENT LSU_uRawAdcUA2_mp "" SWORD Volt 1 100 -6553.600 6553.400 FORMAT "%8.3" ECU_ADDRESS 0xD0017D30 /end MEASUREMENT
/begin MEASUREMENT LSU_uRawAdcUR1_mp "" SWORD Volt 1 100 -6553.600 6553.400 FORMAT "%8.3" ECU_ADDRESS 0xD0017D32 /end MEASUREMENT
/begin MEASUREMENT LSU_uRawAdcUR2_mp "" SWORD Volt 1 100 -6553.600 6553.400 FORMAT "%8.3" ECU_ADDRESS 0xD0017D34 /end MEASUREMENT
/begin MEASUREMENT MemLay_adMpFuncAddress "" ULONG OneToOne 1 100 0.00 4294967295.00 FORMAT "%13.2" ECU_ADDRESS 0xD000188C /end MEASUREMENT
/begin MEASUREMENT MemLay_ctMpAccess "" ULONG OneToOne 1 100 0.00 4294967295.00 FORMAT "%13.2" ECU_ADDRESS 0xD0001888 /end MEASUREMENT
/begin MEASUREMENT MemLay_stMpFunc "" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0001884 /end MEASUREMENT
/begin MEASUREMENT mfpsdia_efMsv_u8 "" UBYTE dez 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD000184E /end MEASUREMENT
/begin MEASUREMENT MILLmp_stMIL "" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0000500 /end MEASUREMENT
/begin MEASUREMENT MILLmp_stMILWoTstr "" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0017719 /end MEASUREMENT
/begin MEASUREMENT MILLmp_stPs "" UBYTE OneToOne 1 100 0.00 255.0 BIT_MASK 0x1 FORMAT "%5.1" ECU_ADDRESS 0xD0000519 /end MEASUREMENT
/begin MEASUREMENT MILLmp_stReqBln "" UBYTE MILLmp_ReqVerb 1 100 0.00 255.000000000 FORMAT "%13.9" ECU_ADDRESS 0xD001B05D /end MEASUREMENT
/begin MEASUREMENT MILLmp_stReqOn "" UBYTE MILLmp_ReqVerb 1 100 0.00 255.000000000 FORMAT "%13.9" ECU_ADDRESS 0xD001B05C /end MEASUREMENT
/begin MEASUREMENT MILLmp_stSt "" UBYTE MILLmp_StVerb 1 100 2.00000000000 65.0000000000 FORMAT "%13.10" ECU_ADDRESS 0xD0017717 /end MEASUREMENT
/begin MEASUREMENT MILLmp_tiRmnBln "" UBYTE t50msxs_q0p05 1 100 0.00 12.75 FORMAT "%5.2" ECU_ADDRESS 0xD0017716 /end MEASUREMENT
/begin MEASUREMENT MILLmp_tiRmnSt "" UBYTE t1sxs_q1 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0017718 /end MEASUREMENT
/begin MEASUREMENT MoCCom_ctErrMMMsg "" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0000504 /end MEASUREMENT
/begin MEASUREMENT MoCCom_stWDAActvMsg "" UBYTE OneToOne 1 100 0.00 255.0 BIT_MASK 0x1 FORMAT "%5.1" ECU_ADDRESS 0xD000051B /end MEASUREMENT
/begin MEASUREMENT MoCSOP_stActvMsg "" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0000505 /end MEASUREMENT
/begin MEASUREMENT MoCSOP_stRdyMsg "" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0000506 /end MEASUREMENT
/begin MEASUREMENT MoFFrm_trqMaxCalMsg "" SWORD Mo_trq_nm_q0p1 1 100 -3276.800 3276.700 FORMAT "%8.3" ECU_ADDRESS 0xD000009C /end MEASUREMENT
/begin MEASUREMENT Mo_stIrvErrReacMsg "" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0000507 /end MEASUREMENT
/begin MEASUREMENT MRly_ctErlyOpng "" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0000501 /end MEASUREMENT
/begin MEASUREMENT MRly_st "" UBYTE OneToOne 1 100 0.00 255.0 BIT_MASK 0x1 FORMAT "%5.1" ECU_ADDRESS 0xD000051A /end MEASUREMENT
/begin MEASUREMENT MRly_stAct "" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0000502 /end MEASUREMENT
/begin MEASUREMENT MRly_stFanShutOff "" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0000503 /end MEASUREMENT
/begin MEASUREMENT MRly_stStkRlytst_mp "" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0017D9A /end MEASUREMENT
/begin MEASUREMENT MRly_stStkRly_mp "" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0017D9B /end MEASUREMENT
/begin MEASUREMENT msabikr2_w "EG mass flow in the exhaust manifold, Bank2" UWORD m_uw_b6553p5 1 100 0.00 6553.500 FORMAT "%8.3" ECU_ADDRESS 0xD0001668 /end MEASUREMENT
/begin MEASUREMENT msabikr_w "EG mass flow in the exhaust manifold" UWORD m_uw_b6553p5 1 100 0.00 6553.500 FORMAT "%8.3" ECU_ADDRESS 0xD000166A /end MEASUREMENT
/begin MEASUREMENT msaovvk2_w "Mass flow exhaust gas minus fuel part upstream of front catalyst, bank 2" UWORD m_uw_b6553p5 1 100 0.00 6553.500 FORMAT "%8.3" ECU_ADDRESS 0xD000166C /end MEASUREMENT
/begin MEASUREMENT msaovvk_w "Mass flow exhaust gas minus fuel part upstream of front catalyst" UWORD m_uw_b6553p5 1 100 0.00 6553.500 FORMAT "%8.3" ECU_ADDRESS 0xD000166E /end MEASUREMENT
/begin MEASUREMENT Msc_ctErr_mp "" UWORD OneToOne 1 100 0.00 65535.00 FORMAT "%8.2" ECU_ADDRESS 0xD0017D2C /end MEASUREMENT
/begin MEASUREMENT nexttizyl "" UBYTE dez 1 100 0.00 255.0 FORMAT "%5.1" ARRAY_SIZE 3 ECU_ADDRESS 0xD000187F /end MEASUREMENT
/begin MEASUREMENT ngas_w "" SWORD nmotg_sw_q0p39 1 100 -12800.16 12799.77 FORMAT "%8.2" ECU_ADDRESS 0xD0000D7E /end MEASUREMENT
/begin MEASUREMENT ngdsmpl "" UBYTE dez 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0001735 /end MEASUREMENT
/begin MEASUREMENT ngdsmpl2 "" UBYTE dez 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0001736 /end MEASUREMENT
/begin MEASUREMENT ngfil "" SBYTE nmotg_sb_q100 1 100 -12800. 12700. FORMAT "%5.0" ECU_ADDRESS 0xD0001742 /end MEASUREMENT
/begin MEASUREMENT ngfil2 "" SBYTE nmotg_sb_q100 1 100 -12800. 12700. FORMAT "%5.0" ECU_ADDRESS 0xD0001743 /end MEASUREMENT
/begin MEASUREMENT ngfil2_w "" SWORD nmotg_sw_q0p39 1 100 -12800.16 12799.77 FORMAT "%8.2" ECU_ADDRESS 0xD0000D80 /end MEASUREMENT
/begin MEASUREMENT ngfil_w "" SWORD nmotg_sw_q0p39 1 100 -12800.16 12799.77 FORMAT "%8.2" ECU_ADDRESS 0xD0000D82 /end MEASUREMENT
/begin MEASUREMENT nltrstdone "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD000190C /end MEASUREMENT
/begin MEASUREMENT nmotbi_w "" UWORD nmot_uw_q0p25 1 100 0.00 16383.75 FORMAT "%8.2" ECU_ADDRESS 0xD0000D84 /end MEASUREMENT
/begin MEASUREMENT nmotll "" UBYTE nmot_ub_q10 1 100 0.00 2550. FORMAT "%5.0" ECU_ADDRESS 0xD0001745 /end MEASUREMENT
/begin MEASUREMENT nmotst "" UBYTE nmot_ub_q10 1 100 0.00 2550. FORMAT "%5.0" ECU_ADDRESS 0xD0001746 /end MEASUREMENT
/begin MEASUREMENT nmotst1t_w "" UWORD nmot_uw_q0p25 1 100 0.00 10000.00 FORMAT "%8.2" ECU_ADDRESS 0xD0000D86 /end MEASUREMENT
/begin MEASUREMENT nmotz "" UBYTE nmot_q10 1 100 0.00 2550. FORMAT "%5.0" ECU_ADDRESS 0xD0001747 /end MEASUREMENT
/begin MEASUREMENT nmot_w "Engine speed" UWORD nmot_uw_q0p25 1 100 0.00 10000.00 FORMAT "%8.2" ECU_ADDRESS 0xD0000D88 /end MEASUREMENT
/begin MEASUREMENT nur1ms "" UBYTE dez 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0001737 /end MEASUREMENT
/begin MEASUREMENT nur1ms2 "" UBYTE dez 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0001738 /end MEASUREMENT
/begin MEASUREMENT offz_w "Off time for follow up sparks" UWORD t_q0p001_ms 1 100 0.00 65.53500 FORMAT "%8.5" ECU_ADDRESS 0xD0001670 /end MEASUREMENT
/begin MEASUREMENT OS_cnt1000msTask "" UWORD OneToOne 1 100 0.00 65535.00 FORMAT "%8.2" ECU_ADDRESS 0xD0016CC2 /end MEASUREMENT
/begin MEASUREMENT OS_cnt100msTask "" UWORD OneToOne 1 100 0.00 65535.00 FORMAT "%8.2" ECU_ADDRESS 0xD0016CBE /end MEASUREMENT
/begin MEASUREMENT OS_cnt10msTask "" UWORD OneToOne 1 100 0.00 65535.00 FORMAT "%8.2" ECU_ADDRESS 0xD0016CB0 /end MEASUREMENT
/begin MEASUREMENT OS_cnt1msTask "" UWORD OneToOne 1 100 0.00 65535.00 FORMAT "%8.2" ECU_ADDRESS 0xD0016CAA /end MEASUREMENT
/begin MEASUREMENT OS_cnt200msTask "" UWORD OneToOne 1 100 0.00 65535.00 FORMAT "%8.2" ECU_ADDRESS 0xD0016CC0 /end MEASUREMENT
/begin MEASUREMENT OS_cnt20msTask "" UWORD OneToOne 1 100 0.00 65535.00 FORMAT "%8.2" ECU_ADDRESS 0xD0016CBA /end MEASUREMENT
/begin MEASUREMENT OS_cnt2msTask "" UWORD OneToOne 1 100 0.00 65535.00 FORMAT "%8.2" ECU_ADDRESS 0xD0016CAC /end MEASUREMENT
/begin MEASUREMENT OS_cnt50msTask "" UWORD OneToOne 1 100 0.00 65535.00 FORMAT "%8.2" ECU_ADDRESS 0xD0016CBC /end MEASUREMENT
/begin MEASUREMENT OS_cnt5msTask "" UWORD OneToOne 1 100 0.00 65535.00 FORMAT "%8.2" ECU_ADDRESS 0xD0016CAE /end MEASUREMENT
/begin MEASUREMENT OS_cntBgTask "" UWORD OneToOne 1 100 0.00 65535.00 FORMAT "%8.2" ECU_ADDRESS 0xD0016CA8 /end MEASUREMENT
/begin MEASUREMENT OS_cntDsmClearTask "" UWORD OneToOne 1 100 0.00 65535.00 FORMAT "%8.2" ECU_ADDRESS 0xD0016CC4 /end MEASUREMENT
/begin MEASUREMENT OS_cntEngReStrtTask "" UWORD OneToOne 1 100 0.00 65535.00 FORMAT "%8.2" ECU_ADDRESS 0xD0016CC8 /end MEASUREMENT
/begin MEASUREMENT OS_cntEpmNoSyncTask "" UWORD OneToOne 1 100 0.00 65535.00 FORMAT "%8.2" ECU_ADDRESS 0xD0016CD2 /end MEASUREMENT
/begin MEASUREMENT OS_cntIniDrvTask "" UWORD OneToOne 1 100 0.00 65535.00 FORMAT "%8.2" ECU_ADDRESS 0xD0016CA4 /end MEASUREMENT
/begin MEASUREMENT OS_cntIniEndTask "" UWORD OneToOne 1 100 0.00 65535.00 FORMAT "%8.2" ECU_ADDRESS 0xD0016CA2 /end MEASUREMENT
/begin MEASUREMENT OS_cntIniTask "" UWORD OneToOne 1 100 0.00 65535.00 FORMAT "%8.2" ECU_ADDRESS 0xD0016CA0 /end MEASUREMENT
/begin MEASUREMENT OS_cntMoTask "" UWORD OneToOne 1 100 0.00 65535.00 FORMAT "%8.2" ECU_ADDRESS 0xD0016CD4 /end MEASUREMENT
/begin MEASUREMENT OS_cntReIniTask "" UWORD OneToOne 1 100 0.00 65535.00 FORMAT "%8.2" ECU_ADDRESS 0xD0016CA6 /end MEASUREMENT
/begin MEASUREMENT OS_cntSyncDummyTask "" UWORD OneToOne 1 100 0.00 65535.00 FORMAT "%8.2" ECU_ADDRESS 0xD0016CD0 /end MEASUREMENT
/begin MEASUREMENT OS_cntSyncFirstTask "" UWORD OneToOne 1 100 0.00 65535.00 FORMAT "%8.2" ECU_ADDRESS 0xD0016CCA /end MEASUREMENT
/begin MEASUREMENT OS_cntSyncIni "" UWORD OneToOne 1 100 0.00 65535.00 FORMAT "%8.2" ECU_ADDRESS 0xD0016CC6 /end MEASUREMENT
/begin MEASUREMENT OS_cntSyncPreTask "" UWORD OneToOne 1 100 0.00 65535.00 FORMAT "%8.2" ECU_ADDRESS 0xD0016CCC /end MEASUREMENT
/begin MEASUREMENT OS_cntSyncSchedTask "" UWORD OneToOne 1 100 0.00 65535.00 FORMAT "%8.2" ECU_ADDRESS 0xD0016CCE /end MEASUREMENT
/begin MEASUREMENT OS_ErrCtr_accessResource_u8 "" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0017053 /end MEASUREMENT
/begin MEASUREMENT OS_ErrCtr_callevel_u8 "" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0017054 /end MEASUREMENT
/begin MEASUREMENT OS_ErrCtr_deadline_u8 "" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001705B /end MEASUREMENT
/begin MEASUREMENT OS_ErrCtr_default_u8 "" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001705A /end MEASUREMENT
/begin MEASUREMENT OS_ErrCtr_generalError_u8 "" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0017059 /end MEASUREMENT
/begin MEASUREMENT OS_ErrCtr_idValue_u8 "" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0017055 /end MEASUREMENT
/begin MEASUREMENT OS_ErrCtr_limit_u8 "" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0017056 /end MEASUREMENT
/begin MEASUREMENT OS_ErrCtr_noFuncState_u8 "" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0017057 /end MEASUREMENT
/begin MEASUREMENT OS_ErrCtr_stackcnt_u8 "" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001705C /end MEASUREMENT
/begin MEASUREMENT OS_ErrCtr_stackstat_u8 "" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001705D /end MEASUREMENT
/begin MEASUREMENT OS_ErrCtr_sum_u8 "" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001705E /end MEASUREMENT
/begin MEASUREMENT OS_ErrCtr_timetable_u8 "" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0017058 /end MEASUREMENT
/begin MEASUREMENT ovlctr "Overlap counter dwellevent" UBYTE dez 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD000189E /end MEASUREMENT
/begin MEASUREMENT phidelmx_w "" UWORD kw_q0p1 1 100 0.00 6553.500 FORMAT "%8.3" ARRAY_SIZE 2 ECU_ADDRESS 0xD0000D8A /end MEASUREMENT
/begin MEASUREMENT phiOffsOld "" SWORD AngleCrS 1 100 -720.0000 719.9780 FORMAT "%8.4" ECU_ADDRESS 0xD0000D7A /end MEASUREMENT
/begin MEASUREMENT phlsnf "Standardized heating power of the Lambda sensor row 1" UBYTE fak_q0p01 1 100 0.00 2.550 FORMAT "%5.3" ECU_ADDRESS 0xD000177A /end MEASUREMENT
/begin MEASUREMENT phlsnf2 "Standardized heating power of the Lambda sensor row 2" UBYTE fak_q0p01 1 100 0.00 2.550 FORMAT "%5.3" ECU_ADDRESS 0xD000177B /end MEASUREMENT
/begin MEASUREMENT phlsnh "Standardized heating power of the Lambda sensor downstream of the catalyzer" UBYTE fak_q0p01 1 100 0.00 2.550 FORMAT "%5.3" ECU_ADDRESS 0xD000177C /end MEASUREMENT
/begin MEASUREMENT phlsnh2 "Standardized heating power of the Lambda sensor 2 downstream of the catalyzer" UBYTE fak_q0p01 1 100 0.00 2.550 FORMAT "%5.3" ECU_ADDRESS 0xD000177D /end MEASUREMENT
/begin MEASUREMENT phlsnv "normalized heating power of lambda sensor upstream of catalyst" UBYTE fak_q0p01 1 100 0.00 2.550 FORMAT "%5.3" ECU_ADDRESS 0xD000177E /end MEASUREMENT
/begin MEASUREMENT phlsnv2 "normalized heating power of lambda sensor 2 upstream of catalyst" UBYTE fak_q0p01 1 100 0.00 2.550 FORMAT "%5.3" ECU_ADDRESS 0xD000177F /end MEASUREMENT
/begin MEASUREMENT Pressure_ECU "Pressure value of the ECU in Pascal" SLONG OneToOne 1 100 -2147483648.00 2147483647.00 FORMAT "%13.2" ECU_ADDRESS 0xD0001E34 /end MEASUREMENT
/begin MEASUREMENT prist_w "Filtered rail pressure real value (absolut pressure)" UWORD p_q0p0005 1 100 0.00 32.76750 FORMAT "%8.5" ECU_ADDRESS 0xD000167A /end MEASUREMENT
/begin MEASUREMENT PthSet_stOvrRunCoord "" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0000508 /end MEASUREMENT
/begin MEASUREMENT PT_rTrq "" SWORD OneToOne 1 100 -32768.00 32767.00 FORMAT "%8.2" ECU_ADDRESS 0xD000009E /end MEASUREMENT
/begin MEASUREMENT rdtklsu2_w "control difference temperature control for LSU, bank 2" SWORD temp_q0p0234 1 100 -768.0000 767.9766 FORMAT "%8.4" ECU_ADDRESS 0xD0001600 /end MEASUREMENT
/begin MEASUREMENT Reset_Env.adLoc "" ULONG OneToOne 1 100 0.00 4294967295.00 FORMAT "%13.2" ECU_ADDRESS 0xD0006140 /end MEASUREMENT
/begin MEASUREMENT Reset_Env.xUserValue "" ULONG OneToOne 1 100 0.00 4294967295.00 FORMAT "%13.2" ECU_ADDRESS 0xD0006144 /end MEASUREMENT
/begin MEASUREMENT Reset_Env.xId "" UWORD Reset_ID 1 100 0.00 12322.0000000 FORMAT "%13.7" ECU_ADDRESS 0xD0006148 /end MEASUREMENT
/begin MEASUREMENT Reset_Env.xGrp "" UBYTE Reset_GrpID 1 100 0.00 26.0000000000 FORMAT "%13.10" ECU_ADDRESS 0xD000614A /end MEASUREMENT
/begin MEASUREMENT Reset_Env.ctRst "" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD000614B /end MEASUREMENT
/begin MEASUREMENT Reset_FlMRErrBuf "" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ARRAY_SIZE 4 ECU_ADDRESS 0xD001707A /end MEASUREMENT
/begin MEASUREMENT Reset_TrapErrIntrBuf "" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ARRAY_SIZE 4 ECU_ADDRESS 0xD0017076 /end MEASUREMENT
/begin MEASUREMENT Reset_xHistBuf "" UWORD Reset_ID 1 100 0.00 12322.0000000 FORMAT "%13.7" ARRAY_SIZE 8 ECU_ADDRESS 0xD00197AC /end MEASUREMENT
/begin MEASUREMENT rinf2_w "facAct. value (word) int. res. Ri-Nernst cell lambda sensor downstream precat bank2" UWORD r_uw_q2 1 100 0.00 131070.0 FORMAT "%8.1" ECU_ADDRESS 0xD0001584 /end MEASUREMENT
/begin MEASUREMENT rinf_w "Actual value (word) internal res. Ri-Nernst cell lambda sensor downstream precat" UWORD r_uw_q2 1 100 0.00 131070.0 FORMAT "%8.1" ECU_ADDRESS 0xD0001586 /end MEASUREMENT
/begin MEASUREMENT rinh2_w "Act. value (word) int. res. Ri-Nernst cell lambda sensor downstream cat bank2" UWORD r_uw_q2 1 100 0.00 131070.0 FORMAT "%8.1" ECU_ADDRESS 0xD0001588 /end MEASUREMENT
/begin MEASUREMENT rinh_w "Actual value (word) internal res. Ri-Nernst cell lambda sensor downstream cat" UWORD r_uw_q2 1 100 0.00 131070.0 FORMAT "%8.1" ECU_ADDRESS 0xD000158A /end MEASUREMENT
/begin MEASUREMENT rinv2_w "Actuel value of internal resistance of lambda sensor 2, pre ca" UWORD r_uw_q2 1 100 0.00 131070.0 FORMAT "%8.1" ECU_ADDRESS 0xD000158C /end MEASUREMENT
/begin MEASUREMENT rinv_w "Actual value of internal resistance of lambda sensor,pre cat (word)" UWORD r_uw_q2 1 100 0.00 131070.0 FORMAT "%8.1" ECU_ADDRESS 0xD000158E /end MEASUREMENT
/begin MEASUREMENT rrine_w_flex "" UWORD r_q0p15625 1 100 0.00 10239.84 FORMAT "%8.2" ARRAY_SIZE 2 ECU_ADDRESS 0xD00000D0 /end MEASUREMENT
/begin MEASUREMENT Rtmo_ctInterrupt_u16 "" UWORD OneToOne 1 100 0.00 65535.00 FORMAT "%8.2" ECU_ADDRESS 0xD0016072 /end MEASUREMENT
/begin MEASUREMENT Rtmo_ctReentrantSample_u32 "" ULONG OneToOne 1 100 0.00 4294967295.00 FORMAT "%13.2" ECU_ADDRESS 0xD00058F0 /end MEASUREMENT
/begin MEASUREMENT Rtmo_ctSampleProc_u8 "" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0017086 /end MEASUREMENT
/begin MEASUREMENT Rtmo_ctSample_u16 "" UWORD OneToOne 1 100 0.00 65535.00 FORMAT "%8.2" ECU_ADDRESS 0xD0016074 /end MEASUREMENT
/begin MEASUREMENT Rtmo_flState_u8 "" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0016DB4 /end MEASUREMENT
/begin MEASUREMENT Rtmo_ti1000msTaskBeg "" ULONG OneToOne 1 100 0.00 4294967295.00 FORMAT "%13.2" ECU_ADDRESS 0xD001565C /end MEASUREMENT
/begin MEASUREMENT Rtmo_ti1000msTaskDur "" ULONG ESC_MACHINE_TICKS_TO_US 1 100 0.00 47721858.8333 FORMAT "%13.4" ECU_ADDRESS 0xD0015664 /end MEASUREMENT
/begin MEASUREMENT Rtmo_ti1000msTaskSched "" ULONG ESC_MACHINE_TICKS_TO_US 1 100 0.00 47721858.8333 FORMAT "%13.4" ECU_ADDRESS 0xD0015660 /end MEASUREMENT
/begin MEASUREMENT Rtmo_ti100msTaskBeg "" ULONG OneToOne 1 100 0.00 4294967295.00 FORMAT "%13.2" ECU_ADDRESS 0xD0015644 /end MEASUREMENT
/begin MEASUREMENT Rtmo_ti100msTaskDur "" ULONG ESC_MACHINE_TICKS_TO_US 1 100 0.00 47721858.8333 FORMAT "%13.4" ECU_ADDRESS 0xD001564C /end MEASUREMENT
/begin MEASUREMENT Rtmo_ti100msTaskSched "" ULONG ESC_MACHINE_TICKS_TO_US 1 100 0.00 47721858.8333 FORMAT "%13.4" ECU_ADDRESS 0xD0015648 /end MEASUREMENT
/begin MEASUREMENT Rtmo_ti10msTaskBeg "" ULONG OneToOne 1 100 0.00 4294967295.00 FORMAT "%13.2" ECU_ADDRESS 0xD0015620 /end MEASUREMENT
/begin MEASUREMENT Rtmo_ti10msTaskDur "" ULONG ESC_MACHINE_TICKS_TO_US 1 100 0.00 47721858.8333 FORMAT "%13.4" ECU_ADDRESS 0xD0015628 /end MEASUREMENT
/begin MEASUREMENT Rtmo_ti10msTaskSched "" ULONG ESC_MACHINE_TICKS_TO_US 1 100 0.00 47721858.8333 FORMAT "%13.4" ECU_ADDRESS 0xD0015624 /end MEASUREMENT
/begin MEASUREMENT Rtmo_ti1msTaskBeg "" ULONG OneToOne 1 100 0.00 4294967295.00 FORMAT "%13.2" ECU_ADDRESS 0xD00155FC /end MEASUREMENT
/begin MEASUREMENT Rtmo_ti1msTaskDur "" ULONG ESC_MACHINE_TICKS_TO_US 1 100 0.00 47721858.8333 FORMAT "%13.4" ECU_ADDRESS 0xD0015604 /end MEASUREMENT
/begin MEASUREMENT Rtmo_ti1msTaskSched "" ULONG ESC_MACHINE_TICKS_TO_US 1 100 0.00 47721858.8333 FORMAT "%13.4" ECU_ADDRESS 0xD0015600 /end MEASUREMENT
/begin MEASUREMENT Rtmo_ti200msTaskBeg "" ULONG OneToOne 1 100 0.00 4294967295.00 FORMAT "%13.2" ECU_ADDRESS 0xD0015650 /end MEASUREMENT
/begin MEASUREMENT Rtmo_ti200msTaskDur "" ULONG ESC_MACHINE_TICKS_TO_US 1 100 0.00 47721858.8333 FORMAT "%13.4" ECU_ADDRESS 0xD0015658 /end MEASUREMENT
/begin MEASUREMENT Rtmo_ti200msTaskSched "" ULONG ESC_MACHINE_TICKS_TO_US 1 100 0.00 47721858.8333 FORMAT "%13.4" ECU_ADDRESS 0xD0015654 /end MEASUREMENT
/begin MEASUREMENT Rtmo_ti20msTaskBeg "" ULONG OneToOne 1 100 0.00 4294967295.00 FORMAT "%13.2" ECU_ADDRESS 0xD001562C /end MEASUREMENT
/begin MEASUREMENT Rtmo_ti20msTaskDur "" ULONG ESC_MACHINE_TICKS_TO_US 1 100 0.00 47721858.8333 FORMAT "%13.4" ECU_ADDRESS 0xD0015634 /end MEASUREMENT
/begin MEASUREMENT Rtmo_ti20msTaskSched "" ULONG ESC_MACHINE_TICKS_TO_US 1 100 0.00 47721858.8333 FORMAT "%13.4" ECU_ADDRESS 0xD0015630 /end MEASUREMENT
/begin MEASUREMENT Rtmo_ti2msTaskBeg "" ULONG OneToOne 1 100 0.00 4294967295.00 FORMAT "%13.2" ECU_ADDRESS 0xD0015608 /end MEASUREMENT
/begin MEASUREMENT Rtmo_ti2msTaskDur "" ULONG ESC_MACHINE_TICKS_TO_US 1 100 0.00 47721858.8333 FORMAT "%13.4" ECU_ADDRESS 0xD0015610 /end MEASUREMENT
/begin MEASUREMENT Rtmo_ti2msTaskSched "" ULONG ESC_MACHINE_TICKS_TO_US 1 100 0.00 47721858.8333 FORMAT "%13.4" ECU_ADDRESS 0xD001560C /end MEASUREMENT
/begin MEASUREMENT Rtmo_ti50msTaskBeg "" ULONG OneToOne 1 100 0.00 4294967295.00 FORMAT "%13.2" ECU_ADDRESS 0xD0015638 /end MEASUREMENT
/begin MEASUREMENT Rtmo_ti50msTaskDur "" ULONG ESC_MACHINE_TICKS_TO_US 1 100 0.00 47721858.8333 FORMAT "%13.4" ECU_ADDRESS 0xD0015640 /end MEASUREMENT
/begin MEASUREMENT Rtmo_ti50msTaskSched "" ULONG ESC_MACHINE_TICKS_TO_US 1 100 0.00 47721858.8333 FORMAT "%13.4" ECU_ADDRESS 0xD001563C /end MEASUREMENT
/begin MEASUREMENT Rtmo_ti5msTaskBeg "" ULONG OneToOne 1 100 0.00 4294967295.00 FORMAT "%13.2" ECU_ADDRESS 0xD0015614 /end MEASUREMENT
/begin MEASUREMENT Rtmo_ti5msTaskDur "" ULONG ESC_MACHINE_TICKS_TO_US 1 100 0.00 47721858.8333 FORMAT "%13.4" ECU_ADDRESS 0xD001561C /end MEASUREMENT
/begin MEASUREMENT Rtmo_ti5msTaskSched "" ULONG ESC_MACHINE_TICKS_TO_US 1 100 0.00 47721858.8333 FORMAT "%13.4" ECU_ADDRESS 0xD0015618 /end MEASUREMENT
/begin MEASUREMENT Rtmo_tiAvrg_Tick "" ULONG Rtmo_Time_us 1 100 0.00 47721858.8333 FORMAT "%13.4" ECU_ADDRESS 0xD00058F4 /end MEASUREMENT
/begin MEASUREMENT Rtmo_tiLoad_u16 "" UWORD Rtmo_Percent_u16 1 100 0.00 99.99847 FORMAT "%8.5" ECU_ADDRESS 0xD0016076 /end MEASUREMENT
/begin MEASUREMENT Rtmo_tiMaxCalldist_Tick "" ULONG Rtmo_Time_us 1 100 0.00 47721858.8333 FORMAT "%13.4" ECU_ADDRESS 0xD00058F8 /end MEASUREMENT
/begin MEASUREMENT Rtmo_tiMaxLoadRun_u16 "" UWORD Rtmo_Percent_u16 1 100 0.00 99.99847 FORMAT "%8.5" ECU_ADDRESS 0xD0016802 /end MEASUREMENT
/begin MEASUREMENT Rtmo_tiMaxLoad_u16 "" UWORD Rtmo_Percent_u16 1 100 0.00 99.99847 FORMAT "%8.5" ECU_ADDRESS 0xD001AF64 /end MEASUREMENT
/begin MEASUREMENT Rtmo_tiMax_Tick "" ULONG Rtmo_Time_us 1 100 0.00 47721858.8333 FORMAT "%13.4" ECU_ADDRESS 0xD00058FC /end MEASUREMENT
/begin MEASUREMENT Rtmo_tiMinCalldist_Tick "" ULONG Rtmo_Time_us 1 100 0.00 47721858.8333 FORMAT "%13.4" ECU_ADDRESS 0xD0005900 /end MEASUREMENT
/begin MEASUREMENT Rtmo_tiMin_Tick "" ULONG Rtmo_Time_us 1 100 0.00 47721858.8333 FORMAT "%13.4" ECU_ADDRESS 0xD0005904 /end MEASUREMENT
/begin MEASUREMENT Rtmo_tiSampleDuration_Tick "" ULONG Rtmo_Time_us 1 100 0.00 47721858.8333 FORMAT "%13.4" ECU_ADDRESS 0xD0005908 /end MEASUREMENT
/begin MEASUREMENT Rtmo_tiSyncTaskBeg "" ULONG OneToOne 1 100 0.00 4294967295.00 FORMAT "%13.2" ARRAY_SIZE 2 ECU_ADDRESS 0xD0015668 /end MEASUREMENT
/begin MEASUREMENT Rtmo_tiSyncTaskDur "" ULONG ESC_MACHINE_TICKS_TO_US 1 100 0.00 47721858.8333 FORMAT "%13.4" ARRAY_SIZE 2 ECU_ADDRESS 0xD0015678 /end MEASUREMENT
/begin MEASUREMENT Rtmo_tiSyncTaskSched "" ULONG ESC_MACHINE_TICKS_TO_US 1 100 0.00 47721858.8333 FORMAT "%13.4" ARRAY_SIZE 2 ECU_ADDRESS 0xD0015670 /end MEASUREMENT
/begin MEASUREMENT s1fl3p0c "" UBYTE dez 1 100 0.00 255.0 FORMAT "%5.1" ARRAY_SIZE 3 ECU_ADDRESS 0xD0001748 /end MEASUREMENT
/begin MEASUREMENT SBBF.B_dlsen "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD0000870 /end MEASUREMENT
/begin MEASUREMENT SBBF.B_sbb "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD0000872 /end MEASUREMENT
/begin MEASUREMENT SBBF.B_stkcvb "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x8 FORMAT "%13.11" ECU_ADDRESS 0xD0000872 /end MEASUREMENT
/begin MEASUREMENT SBBF.B_usstkcvb "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x10 FORMAT "%13.11" ECU_ADDRESS 0xD0000872 /end MEASUREMENT
/begin MEASUREMENT SBBF2.B_dlsen "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD0000882 /end MEASUREMENT
/begin MEASUREMENT SBBF2.B_sbb "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD0000884 /end MEASUREMENT
/begin MEASUREMENT SBBF2.B_stkcvb "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x8 FORMAT "%13.11" ECU_ADDRESS 0xD0000884 /end MEASUREMENT
/begin MEASUREMENT SBBF2.B_usstkcvb "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x10 FORMAT "%13.11" ECU_ADDRESS 0xD0000884 /end MEASUREMENT
/begin MEASUREMENT SBBH.B_dlsen "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD0000894 /end MEASUREMENT
/begin MEASUREMENT SBBH.B_sbb "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD0000896 /end MEASUREMENT
/begin MEASUREMENT SBBH.B_stkcvb "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x8 FORMAT "%13.11" ECU_ADDRESS 0xD0000896 /end MEASUREMENT
/begin MEASUREMENT SBBH.B_usstkcvb "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x10 FORMAT "%13.11" ECU_ADDRESS 0xD0000896 /end MEASUREMENT
/begin MEASUREMENT SBBH2.B_dlsen "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD00008A6 /end MEASUREMENT
/begin MEASUREMENT SBBH2.B_sbb "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD00008A8 /end MEASUREMENT
/begin MEASUREMENT SBBH2.B_stkcvb "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x8 FORMAT "%13.11" ECU_ADDRESS 0xD00008A8 /end MEASUREMENT
/begin MEASUREMENT SBBH2.B_usstkcvb "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x10 FORMAT "%13.11" ECU_ADDRESS 0xD00008A8 /end MEASUREMENT
/begin MEASUREMENT SBBZPV.B_dlsen "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD00008B8 /end MEASUREMENT
/begin MEASUREMENT SBBZPV.B_dlssigen "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD00008B9 /end MEASUREMENT
/begin MEASUREMENT SBBZPV.B_hsxeset "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD00008BB /end MEASUREMENT
/begin MEASUREMENT SBBZPV.B_minoksbb "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x2 FORMAT "%13.11" ECU_ADDRESS 0xD00008BB /end MEASUREMENT
/begin MEASUREMENT SBBZPV.B_sigoksbb "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x8 FORMAT "%13.11" ECU_ADDRESS 0xD00008BB /end MEASUREMENT
/begin MEASUREMENT SBBZPV2.B_dlsen "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD00008CA /end MEASUREMENT
/begin MEASUREMENT SBBZPV2.B_dlssigen "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD00008CB /end MEASUREMENT
/begin MEASUREMENT SBBZPV2.B_hsxeset "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x1 FORMAT "%13.11" ECU_ADDRESS 0xD00008CD /end MEASUREMENT
/begin MEASUREMENT SBBZPV2.B_minoksbb "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x2 FORMAT "%13.11" ECU_ADDRESS 0xD00008CD /end MEASUREMENT
/begin MEASUREMENT SBBZPV2.B_sigoksbb "" UBYTE B_TRUE 1 100 0.00 1.00000000000 BIT_MASK 0x8 FORMAT "%13.11" ECU_ADDRESS 0xD00008CD /end MEASUREMENT
/begin MEASUREMENT Shtrp_stSVSReq "" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0000509 /end MEASUREMENT
/begin MEASUREMENT Signals_Default "" SLONG OneToOne 1 100 -2147483648.00 2147483647.00 FORMAT "%13.2" ECU_ADDRESS 0xD0006184 /end MEASUREMENT
/begin MEASUREMENT Strt_stPs "" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD000050A /end MEASUREMENT
/begin MEASUREMENT Strt_stStaActv "" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD000050B /end MEASUREMENT
/begin MEASUREMENT stSyncOld "" UBYTE dez 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0001741 /end MEASUREMENT
/begin MEASUREMENT SyC_ctDeadline1msErr "" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001708E /end MEASUREMENT
/begin MEASUREMENT SyC_ctInit "" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001A5B8 /end MEASUREMENT
/begin MEASUREMENT SyC_ctTiPostDrvMax "" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AF66 /end MEASUREMENT
/begin MEASUREMENT SyC_ctTiPreDrvMax "" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AF68 /end MEASUREMENT
/begin MEASUREMENT SyC_ctUnderVltg "" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001A5B9 /end MEASUREMENT
/begin MEASUREMENT SyC_stHistTiPostDrvMax "" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AF67 /end MEASUREMENT
/begin MEASUREMENT SyC_stHistTiPreDrvMax "" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001AF69 /end MEASUREMENT
/begin MEASUREMENT SyC_stMn "" UBYTE ExeCon_State_01 1 100 0.00 3.00000000000 FORMAT "%13.11" ECU_ADDRESS 0xD000050C /end MEASUREMENT
/begin MEASUREMENT SyC_stMnOld "" UBYTE ExeCon_State_01 1 100 0.00 3.00000000000 FORMAT "%13.11" ECU_ADDRESS 0xD000050D /end MEASUREMENT
/begin MEASUREMENT SyC_stPostDrv "" UBYTE SyC_PostDrv_State 1 100 0.00 8.00000000000 FORMAT "%13.11" ECU_ADDRESS 0xD000050E /end MEASUREMENT
/begin MEASUREMENT SyC_stPostDrvFin "" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001A5A8 /end MEASUREMENT
/begin MEASUREMENT SyC_stPreDrv "" UBYTE SyC_PreDrv_State 1 100 0.00 9.00000000000 FORMAT "%13.11" ECU_ADDRESS 0xD000050F /end MEASUREMENT
/begin MEASUREMENT SyC_stPreDrvFin "" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD001A5A9 /end MEASUREMENT
/begin MEASUREMENT SyC_stSub "Current system/ECU sub-state" UBYTE ExeCon_State_02 1 100 0.00 6.00000000000 FORMAT "%13.11" ECU_ADDRESS 0xD0000510 /end MEASUREMENT
/begin MEASUREMENT SyC_stSubOld "" UBYTE ExeCon_State_02 1 100 0.00 6.00000000000 FORMAT "%13.11" ECU_ADDRESS 0xD0000511 /end MEASUREMENT
/begin MEASUREMENT SyC_stSwtOn_mp "" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0017D9C /end MEASUREMENT
/begin MEASUREMENT SyC_stT15 "" UBYTE OneToOne 1 100 0.00 255.0 BIT_MASK 0x1 FORMAT "%5.1" ECU_ADDRESS 0xD000051C /end MEASUREMENT
/begin MEASUREMENT SyC_tiBoot_mp "" ULONG Time_usec_q1_COMPU 1 100 0.00 4294967295.00 FORMAT "%13.2" ECU_ADDRESS 0xD0017A38 /end MEASUREMENT
/begin MEASUREMENT SyC_tiDrv "" ULONG Time_msec_q10_COMPU 1 100 0.00 42949672950.0 FORMAT "%13.1" ECU_ADDRESS 0xD0001E44 /end MEASUREMENT
/begin MEASUREMENT SyC_tiFrst10ms "" UWORD Time_msec_q1_COMPU 1 100 0.00 65535.00 FORMAT "%8.2" ECU_ADDRESS 0xD00000BE /end MEASUREMENT
/begin MEASUREMENT SyC_tiIniEnd_mp "" UWORD Time_usec_q1_COMPU 1 100 0.00 65535.00 FORMAT "%8.2" ECU_ADDRESS 0xD0017D36 /end MEASUREMENT
/begin MEASUREMENT SyC_tiIniSyn_mp "" UWORD Time_usec_q1_COMPU 1 100 0.00 65535.00 FORMAT "%8.2" ECU_ADDRESS 0xD0017D38 /end MEASUREMENT
/begin MEASUREMENT SyC_tiIni_mp "" ULONG Time_usec_q1_COMPU 1 100 0.00 4294967295.00 FORMAT "%13.2" ECU_ADDRESS 0xD0017A3C /end MEASUREMENT
/begin MEASUREMENT SyC_tiPostDrv "" ULONG Time_msec_q10_COMPU 1 100 0.00 42949672950.0 FORMAT "%13.1" ECU_ADDRESS 0xD0001E48 /end MEASUREMENT
/begin MEASUREMENT SyC_tiPreDrv "" ULONG Time_msec_q10_COMPU 1 100 0.00 42949672950.0 FORMAT "%13.1" ECU_ADDRESS 0xD0001E4C /end MEASUREMENT
/begin MEASUREMENT SyC_tiUnderVltg_mp "" UBYTE OneToOne_ms 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0017D9D /end MEASUREMENT
/begin MEASUREMENT synstate "" UBYTE dez 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD000174B /end MEASUREMENT
/begin MEASUREMENT szfuba_w "Dwell time for follow up sparks" UWORD t_q0p001_ms 1 100 0.00 65.53500 FORMAT "%8.5" ECU_ADDRESS 0xD000167C /end MEASUREMENT
/begin MEASUREMENT szout_w "Dwell time" UWORD t_q0p001_ms 1 100 0.00 65.53500 FORMAT "%8.5" ECU_ADDRESS 0xD000167E /end MEASUREMENT
/begin MEASUREMENT T15_st "" UBYTE OneToOne 1 100 0.00 255.0 BIT_MASK 0x1 FORMAT "%5.1" ECU_ADDRESS 0xD000051D /end MEASUREMENT
/begin MEASUREMENT T15_stRaw "" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0000512 /end MEASUREMENT
/begin MEASUREMENT tabst_w "stop time" UWORD t1sxs_uw_q1 1 100 0.00 65535.00 FORMAT "%8.2" ECU_ADDRESS 0xD0001680 /end MEASUREMENT
/begin MEASUREMENT tavvkm2_w "Exhaust gas temperature in front of pre-catalyst out of model, bank2" UWORD temp_q0p0234_o273 1 100 -273.1500 1262.827 FORMAT "%8.3" ECU_ADDRESS 0xD0001682 /end MEASUREMENT
/begin MEASUREMENT tavvkm_w "Exhaust gas temperature in front of pre-catalyst out of model" UWORD temp_q0p0234_o273 1 100 -273.1500 1262.827 FORMAT "%8.3" ECU_ADDRESS 0xD0001684 /end MEASUREMENT
/begin MEASUREMENT te2_l "" ULONG t1p0usxms 1 100 0.00 4294967.29500 FORMAT "%13.5" ECU_ADDRESS 0xD0001E78 /end MEASUREMENT
/begin MEASUREMENT TestCD_Byp_CodeGen_T_Add_u8_Add "Automatic generated Measurement after Bypass-Hook" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0017D3B /end MEASUREMENT
/begin MEASUREMENT TestCD_Byp_CodeGen_T_Add_u8_BefAdd "Automatic generated Measurement before Bypass-Hook" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0017D3C /end MEASUREMENT
/begin MEASUREMENT TestCD_Byp_CodeGen_T_Rpl_u32 "Automatic generated Measurement after Bypass-Hook" ULONG OneToOne 1 100 0.00 4294967295.00 FORMAT "%13.2" ECU_ADDRESS 0xD0017890 /end MEASUREMENT
/begin MEASUREMENT TestCD_Byp_CodeGen_T_Rpl_u32BefRepl "Automatic generated Measurement before Bypass-Hook" ULONG OneToOne 1 100 0.00 4294967295.00 FORMAT "%13.2" ECU_ADDRESS 0xD0017894 /end MEASUREMENT
/begin MEASUREMENT TestCD_Byp_IP_T_Add_s32Add "Automatic generated Measurement after Bypass-Hook" SLONG OneToOne 1 100 -2147483648.00 2147483647.00 FORMAT "%13.2" ECU_ADDRESS 0xD0017898 /end MEASUREMENT
/begin MEASUREMENT TestCD_Byp_IP_T_Add_s32BefAdd "Automatic generated Measurement before Bypass-Hook" SLONG OneToOne 1 100 -2147483648.00 2147483647.00 FORMAT "%13.2" ECU_ADDRESS 0xD001789C /end MEASUREMENT
/begin MEASUREMENT TestCD_Byp_TestHookArray1_T_Rpl_u8_0 "Automatic generated Measurement after Bypass-Hook" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0017D3D /end MEASUREMENT
/begin MEASUREMENT TestCD_Byp_TestHookArray1_T_Rpl_u8_0BefRepl "Automatic generated Measurement before Bypass-Hook" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0017D3E /end MEASUREMENT
/begin MEASUREMENT TestCD_Byp_TestHookArray1_T_Rpl_u8_1 "Automatic generated Measurement after Bypass-Hook" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0017D3F /end MEASUREMENT
/begin MEASUREMENT TestCD_Byp_TestHookArray1_T_Rpl_u8_1BefRepl "Automatic generated Measurement before Bypass-Hook" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0017D40 /end MEASUREMENT
/begin MEASUREMENT TestCD_Byp_TestHookArray1_T_Rpl_u8_2 "Automatic generated Measurement after Bypass-Hook" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0017D41 /end MEASUREMENT
/begin MEASUREMENT TestCD_Byp_TestHookArray1_T_Rpl_u8_2BefRepl "Automatic generated Measurement before Bypass-Hook" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0017D42 /end MEASUREMENT
/begin MEASUREMENT TestCD_Byp_TestHookArray1_T_Rpl_u8_3 "Automatic generated Measurement after Bypass-Hook" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0017D43 /end MEASUREMENT
/begin MEASUREMENT TestCD_Byp_TestHookArray1_T_Rpl_u8_3BefRepl "Automatic generated Measurement before Bypass-Hook" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0017D44 /end MEASUREMENT
/begin MEASUREMENT TestCD_Byp_TestHookArray1_T_Rpl_u8_4 "Automatic generated Measurement after Bypass-Hook" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0017D45 /end MEASUREMENT
/begin MEASUREMENT TestCD_Byp_TestHookArray1_T_Rpl_u8_4BefRepl "Automatic generated Measurement before Bypass-Hook" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0017D46 /end MEASUREMENT
/begin MEASUREMENT TestCD_Byp_TestHookArray2_T_Rpl_u8_0 "Automatic generated Measurement after Bypass-Hook" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0017D47 /end MEASUREMENT
/begin MEASUREMENT TestCD_Byp_TestHookArray2_T_Rpl_u8_0BefRepl "Automatic generated Measurement before Bypass-Hook" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0017D48 /end MEASUREMENT
/begin MEASUREMENT TestCD_Byp_TestHookArray2_T_Rpl_u8_1 "Automatic generated Measurement after Bypass-Hook" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0017D49 /end MEASUREMENT
/begin MEASUREMENT TestCD_Byp_TestHookArray2_T_Rpl_u8_1BefRepl "Automatic generated Measurement before Bypass-Hook" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0017D4A /end MEASUREMENT
/begin MEASUREMENT TestCD_Byp_TestHookArray2_T_Rpl_u8_2 "Automatic generated Measurement after Bypass-Hook" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0017D4B /end MEASUREMENT
/begin MEASUREMENT TestCD_Byp_TestHookArray2_T_Rpl_u8_2BefRepl "Automatic generated Measurement before Bypass-Hook" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0017D4C /end MEASUREMENT
/begin MEASUREMENT TestCD_Byp_TestHookArray2_T_Rpl_u8_3 "Automatic generated Measurement after Bypass-Hook" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0017D4D /end MEASUREMENT
/begin MEASUREMENT TestCD_Byp_TestHookArray2_T_Rpl_u8_3BefRepl "Automatic generated Measurement before Bypass-Hook" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0017D4E /end MEASUREMENT
/begin MEASUREMENT TestCD_Byp_TestHookArray2_T_Rpl_u8_4 "Automatic generated Measurement after Bypass-Hook" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0017D4F /end MEASUREMENT
/begin MEASUREMENT TestCD_Byp_TestHookArray2_T_Rpl_u8_4BefRepl "Automatic generated Measurement before Bypass-Hook" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0017D50 /end MEASUREMENT
/begin MEASUREMENT TestCD_Byp_TestHookArray3_T_Add_u8_0Add "Automatic generated Measurement after Bypass-Hook" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0017D51 /end MEASUREMENT
/begin MEASUREMENT TestCD_Byp_TestHookArray3_T_Add_u8_0BefAdd "Automatic generated Measurement before Bypass-Hook" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0017D52 /end MEASUREMENT
/begin MEASUREMENT TestCD_Byp_TestHookArray3_T_Add_u8_1Add "Automatic generated Measurement after Bypass-Hook" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0017D53 /end MEASUREMENT
/begin MEASUREMENT TestCD_Byp_TestHookArray3_T_Add_u8_1BefAdd "Automatic generated Measurement before Bypass-Hook" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0017D54 /end MEASUREMENT
/begin MEASUREMENT TestCD_Byp_TestHookArray3_T_Add_u8_2Add "Automatic generated Measurement after Bypass-Hook" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0017D55 /end MEASUREMENT
/begin MEASUREMENT TestCD_Byp_TestHookArray3_T_Add_u8_2BefAdd "Automatic generated Measurement before Bypass-Hook" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0017D56 /end MEASUREMENT
/begin MEASUREMENT TestCD_Byp_TestHookArray3_T_Add_u8_3Add "Automatic generated Measurement after Bypass-Hook" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0017D57 /end MEASUREMENT
/begin MEASUREMENT TestCD_Byp_TestHookArray3_T_Add_u8_3BefAdd "Automatic generated Measurement before Bypass-Hook" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0017D58 /end MEASUREMENT
/begin MEASUREMENT TestCD_Byp_TestHookArray3_T_Add_u8_4Add "Automatic generated Measurement after Bypass-Hook" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0017D59 /end MEASUREMENT
/begin MEASUREMENT TestCD_Byp_TestHookArray3_T_Add_u8_4BefAdd "Automatic generated Measurement before Bypass-Hook" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0017D5A /end MEASUREMENT
/begin MEASUREMENT TestCD_Byp_TestHook_N_Add_r32Add "Automatic generated Measurement after Bypass-Hook" FLOAT32_IEEE OneToOne 1 100 -100000000. 100000000. FORMAT "%10.0" ECU_ADDRESS 0xD00178A0 /end MEASUREMENT
/begin MEASUREMENT TestCD_Byp_TestHook_N_Add_r32BefAdd "Automatic generated Measurement before Bypass-Hook" FLOAT32_IEEE OneToOne 1 100 -100000000. 100000000. FORMAT "%10.0" ECU_ADDRESS 0xD00178A4 /end MEASUREMENT
/begin MEASUREMENT TestCD_Byp_TestHook_N_Add_s16 "Automatic generated Measurement after Bypass-Hook" SWORD OneToOne 1 100 -32768.00 32767.00 FORMAT "%8.2" ECU_ADDRESS 0xD0017A42 /end MEASUREMENT
/begin MEASUREMENT TestCD_Byp_TestHook_N_Add_s16BefRepl "Automatic generated Measurement before Bypass-Hook" SWORD OneToOne 1 100 -32768.00 32767.00 FORMAT "%8.2" ECU_ADDRESS 0xD0017A44 /end MEASUREMENT
/begin MEASUREMENT TestCD_Byp_TestHook_N_Add_s32Add "Automatic generated Measurement after Bypass-Hook" SLONG OneToOne 1 100 -2147483648.00 2147483647.00 FORMAT "%13.2" ECU_ADDRESS 0xD00178A8 /end MEASUREMENT
/begin MEASUREMENT TestCD_Byp_TestHook_N_Add_s32BefAdd "Automatic generated Measurement before Bypass-Hook" SLONG OneToOne 1 100 -2147483648.00 2147483647.00 FORMAT "%13.2" ECU_ADDRESS 0xD00178AC /end MEASUREMENT
/begin MEASUREMENT TestCD_Byp_TestHook_N_Add_s8Add1 "Automatic generated Measurement before Bypass-Hook" SBYTE OneToOne 1 100 -128.0 127.0 FORMAT "%5.1" ECU_ADDRESS 0xD0017D5B /end MEASUREMENT
/begin MEASUREMENT TestCD_Byp_TestHook_N_Add_s8Add2 "Automatic generated Measurement after Bypass-Hook" SBYTE OneToOne 1 100 -128.0 127.0 FORMAT "%5.1" ECU_ADDRESS 0xD0017D5C /end MEASUREMENT
/begin MEASUREMENT TestCD_Byp_TestHook_N_Add_u16Add "Automatic generated Measurement after Bypass-Hook" UWORD OneToOne 1 100 0.00 65535.00 FORMAT "%8.2" ECU_ADDRESS 0xD0017A46 /end MEASUREMENT
/begin MEASUREMENT TestCD_Byp_TestHook_N_Add_u16BefAdd "Automatic generated Measurement before Bypass-Hook" UWORD OneToOne 1 100 0.00 65535.00 FORMAT "%8.2" ECU_ADDRESS 0xD0017A48 /end MEASUREMENT
/begin MEASUREMENT TestCD_Byp_TestHook_N_Add_u32Add "Automatic generated Measurement after Bypass-Hook" ULONG OneToOne 1 100 0.00 4294967295.00 FORMAT "%13.2" ECU_ADDRESS 0xD00178B0 /end MEASUREMENT
/begin MEASUREMENT TestCD_Byp_TestHook_N_Add_u32BefAdd "Automatic generated Measurement before Bypass-Hook" ULONG OneToOne 1 100 0.00 4294967295.00 FORMAT "%13.2" ECU_ADDRESS 0xD00178B4 /end MEASUREMENT
/begin MEASUREMENT TestCD_Byp_TestHook_N_Add_u8Add "Automatic generated Measurement after Bypass-Hook" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0017D5D /end MEASUREMENT
/begin MEASUREMENT TestCD_Byp_TestHook_N_Add_u8BefAdd "Automatic generated Measurement before Bypass-Hook" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0017D5E /end MEASUREMENT
/begin MEASUREMENT TestCD_Byp_TestHook_N_Rpl_r32 "Automatic generated Measurement after Bypass-Hook" FLOAT32_IEEE OneToOne 1 100 -100000000. 100000000. FORMAT "%10.0" ECU_ADDRESS 0xD00178B8 /end MEASUREMENT
/begin MEASUREMENT TestCD_Byp_TestHook_N_Rpl_r32BefRepl "Automatic generated Measurement before Bypass-Hook" FLOAT32_IEEE OneToOne 1 100 -100000000. 100000000. FORMAT "%10.0" ECU_ADDRESS 0xD00178BC /end MEASUREMENT
/begin MEASUREMENT TestCD_Byp_TestHook_N_Rpl_s16 "Automatic generated Measurement after Bypass-Hook" SWORD OneToOne 1 100 -32768.00 32767.00 FORMAT "%8.2" ECU_ADDRESS 0xD0017A4A /end MEASUREMENT
/begin MEASUREMENT TestCD_Byp_TestHook_N_Rpl_s16BefRepl "Automatic generated Measurement before Bypass-Hook" SWORD OneToOne 1 100 -32768.00 32767.00 FORMAT "%8.2" ECU_ADDRESS 0xD0017A4C /end MEASUREMENT
/begin MEASUREMENT TestCD_Byp_TestHook_N_Rpl_s32 "Automatic generated Measurement after Bypass-Hook" SLONG OneToOne 1 100 -2147483648.00 2147483647.00 FORMAT "%13.2" ECU_ADDRESS 0xD00178C0 /end MEASUREMENT
/begin MEASUREMENT TestCD_Byp_TestHook_N_Rpl_s32BefRepl "Automatic generated Measurement before Bypass-Hook" SLONG OneToOne 1 100 -2147483648.00 2147483647.00 FORMAT "%13.2" ECU_ADDRESS 0xD00178C4 /end MEASUREMENT
/begin MEASUREMENT TestCD_Byp_TestHook_N_Rpl_s8Repl "Automatic generated Measurement after Bypass-Hook" SBYTE OneToOne 1 100 -128.0 127.0 FORMAT "%5.1" ECU_ADDRESS 0xD0017D5F /end MEASUREMENT
/begin MEASUREMENT TestCD_Byp_TestHook_N_Rpl_u16 "Automatic generated Measurement after Bypass-Hook" UWORD OneToOne 1 100 0.00 65535.00 FORMAT "%8.2" ECU_ADDRESS 0xD0017A4E /end MEASUREMENT
/begin MEASUREMENT TestCD_Byp_TestHook_N_Rpl_u16BefRepl "Automatic generated Measurement before Bypass-Hook" UWORD OneToOne 1 100 0.00 65535.00 FORMAT "%8.2" ECU_ADDRESS 0xD0017A50 /end MEASUREMENT
/begin MEASUREMENT TestCD_Byp_TestHook_N_Rpl_u32 "Automatic generated Measurement after Bypass-Hook" ULONG OneToOne 1 100 0.00 4294967295.00 FORMAT "%13.2" ECU_ADDRESS 0xD00178C8 /end MEASUREMENT
/begin MEASUREMENT TestCD_Byp_TestHook_N_Rpl_u32BefRepl "Automatic generated Measurement before Bypass-Hook" ULONG OneToOne 1 100 0.00 4294967295.00 FORMAT "%13.2" ECU_ADDRESS 0xD00178CC /end MEASUREMENT
/begin MEASUREMENT TestCD_Byp_TestHook_N_Rpl_u8 "Automatic generated Measurement after Bypass-Hook" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0017D60 /end MEASUREMENT
/begin MEASUREMENT TestCD_Byp_TestHook_N_Rpl_u8BefRepl "Automatic generated Measurement before Bypass-Hook" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0017D61 /end MEASUREMENT
/begin MEASUREMENT TestCD_Byp_TestHook_T_Add_r32Add "Automatic generated Measurement after Bypass-Hook" FLOAT32_IEEE OneToOne 1 100 -100000000. 100000000. FORMAT "%10.0" ECU_ADDRESS 0xD00178D0 /end MEASUREMENT
/begin MEASUREMENT TestCD_Byp_TestHook_T_Add_r32BefAdd "Automatic generated Measurement before Bypass-Hook" FLOAT32_IEEE OneToOne 1 100 -100000000. 100000000. FORMAT "%10.0" ECU_ADDRESS 0xD00178D4 /end MEASUREMENT
/begin MEASUREMENT TestCD_Byp_TestHook_T_Add_s16Add "Automatic generated Measurement after Bypass-Hook" SWORD OneToOne 1 100 -32768.00 32767.00 FORMAT "%8.2" ECU_ADDRESS 0xD0017A52 /end MEASUREMENT
/begin MEASUREMENT TestCD_Byp_TestHook_T_Add_s16BefAdd "Automatic generated Measurement before Bypass-Hook" SWORD OneToOne 1 100 -32768.00 32767.00 FORMAT "%8.2" ECU_ADDRESS 0xD0017A54 /end MEASUREMENT
/begin MEASUREMENT TestCD_Byp_TestHook_T_Add_s8Add "Automatic generated Measurement after Bypass-Hook" SBYTE OneToOne 1 100 -128.0 127.0 FORMAT "%5.1" ECU_ADDRESS 0xD0017D62 /end MEASUREMENT
/begin MEASUREMENT TestCD_Byp_TestHook_T_Add_s8BefAdd "Automatic generated Measurement before Bypass-Hook" SBYTE OneToOne 1 100 -128.0 127.0 FORMAT "%5.1" ECU_ADDRESS 0xD0017D63 /end MEASUREMENT
/begin MEASUREMENT TestCD_Byp_TestHook_T_Add_u16 "Automatic generated Measurement after Bypass-Hook" UWORD OneToOne 1 100 0.00 65535.00 FORMAT "%8.2" ECU_ADDRESS 0xD0017A56 /end MEASUREMENT
/begin MEASUREMENT TestCD_Byp_TestHook_T_Add_u32BefAdd "Automatic generated Measurement before Bypass-Hook" ULONG OneToOne 1 100 0.00 4294967295.00 FORMAT "%13.2" ECU_ADDRESS 0xD00178D8 /end MEASUREMENT
/begin MEASUREMENT TestCD_Byp_TestHook_T_Add_u32_Add "Automatic generated Measurement after Bypass-Hook" ULONG OneToOne 1 100 0.00 4294967295.00 FORMAT "%13.2" ECU_ADDRESS 0xD00178DC /end MEASUREMENT
/begin MEASUREMENT TestCD_Byp_TestHook_T_Add_u8Add "Automatic generated Measurement after Bypass-Hook" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0017D64 /end MEASUREMENT
/begin MEASUREMENT TestCD_Byp_TestHook_T_Add_u8BefAdd "Automatic generated Measurement before Bypass-Hook" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0017D65 /end MEASUREMENT
/begin MEASUREMENT TestCD_Byp_TestHook_T_Read_Bit_2 "Automatic generated Measurement after Bypass-Hook" UBYTE OneToOne 1 100 0.00 1.000 BIT_MASK 0x2 FORMAT "%5.3" ECU_ADDRESS 0xD0001921 /end MEASUREMENT
/begin MEASUREMENT TestCD_Byp_TestHook_T_Read_Bit_2BefRepl "Automatic generated Measurement before Bypass-Hook" UBYTE OneToOne 1 100 0.00 1.000 BIT_MASK 0x2 FORMAT "%5.3" ECU_ADDRESS 0xD0001914 /end MEASUREMENT
/begin MEASUREMENT TestCD_Byp_TestHook_T_Read_Bit_BefRepl "Automatic generated Measurement before Bypass-Hook" UBYTE OneToOne 1 100 0.00 1.000 BIT_MASK 0x1 FORMAT "%5.3" ECU_ADDRESS 0xD000191E /end MEASUREMENT
/begin MEASUREMENT TestCD_Byp_TestHook_T_Rpl_r32 "Automatic generated Measurement after Bypass-Hook" FLOAT32_IEEE OneToOne 1 100 -100000000. 100000000. FORMAT "%10.0" ECU_ADDRESS 0xD00178E0 /end MEASUREMENT
/begin MEASUREMENT TestCD_Byp_TestHook_T_Rpl_r32_BefRepl "Automatic generated Measurement before Bypass-Hook" FLOAT32_IEEE OneToOne 1 100 -100000000. 100000000. FORMAT "%10.0" ECU_ADDRESS 0xD00178E4 /end MEASUREMENT
/begin MEASUREMENT TestCD_Byp_TestHook_T_Rpl_s16BefRepl "Automatic generated Measurement before Bypass-Hook" SWORD OneToOne 1 100 -32768.00 32767.00 FORMAT "%8.2" ECU_ADDRESS 0xD0017A58 /end MEASUREMENT
/begin MEASUREMENT TestCD_Byp_TestHook_T_Rpl_s16Repl "Automatic generated Measurement after Bypass-Hook" SWORD OneToOne 1 100 -32768.00 32767.00 FORMAT "%8.2" ECU_ADDRESS 0xD0017A5A /end MEASUREMENT
/begin MEASUREMENT TestCD_Byp_TestHook_T_Rpl_s32 "Automatic generated Measurement after Bypass-Hook" SLONG OneToOne 1 100 -2147483648.00 2147483647.00 FORMAT "%13.2" ECU_ADDRESS 0xD00178E8 /end MEASUREMENT
/begin MEASUREMENT TestCD_Byp_TestHook_T_Rpl_s32BefRepl "Automatic generated Measurement before Bypass-Hook" SLONG OneToOne 1 100 -2147483648.00 2147483647.00 FORMAT "%13.2" ECU_ADDRESS 0xD00178EC /end MEASUREMENT
/begin MEASUREMENT TestCD_Byp_TestHook_T_Rpl_s8_BefRepl "Automatic generated Measurement before Bypass-Hook" SBYTE OneToOne 1 100 -128.0 127.0 FORMAT "%5.1" ECU_ADDRESS 0xD0017D66 /end MEASUREMENT
/begin MEASUREMENT TestCD_Byp_TestHook_T_Rpl_u16BefRepl "Automatic generated Measurement before Bypass-Hook" UWORD OneToOne 1 100 0.00 65535.00 FORMAT "%8.2" ECU_ADDRESS 0xD0017A5C /end MEASUREMENT
/begin MEASUREMENT TestCD_Byp_TestHook_T_Rpl_u16Repl "Automatic generated Measurement after Bypass-Hook" UWORD OneToOne 1 100 0.00 65535.00 FORMAT "%8.2" ECU_ADDRESS 0xD0017A5E /end MEASUREMENT
/begin MEASUREMENT TestCD_Byp_TestHook_T_Rpl_u32 "Automatic generated Measurement after Bypass-Hook" ULONG OneToOne 1 100 0.00 4294967295.00 FORMAT "%13.2" ECU_ADDRESS 0xD00178F0 /end MEASUREMENT
/begin MEASUREMENT TestCD_Byp_TestHook_T_Rpl_u32BefRepl "Automatic generated Measurement before Bypass-Hook" ULONG OneToOne 1 100 0.00 4294967295.00 FORMAT "%13.2" ECU_ADDRESS 0xD00178F4 /end MEASUREMENT
/begin MEASUREMENT TestCD_Byp_TestHook_T_Rpl_u8 "Automatic generated Measurement after Bypass-Hook" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0017D67 /end MEASUREMENT
/begin MEASUREMENT TestCD_Byp_TestHook_T_Rpl_u8BefRepl "Automatic generated Measurement before Bypass-Hook" UBYTE OneToOne 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0017D68 /end MEASUREMENT
/begin MEASUREMENT tez_l "Effective Injection Time." ULONG t1p0usxms 1 100 0.00 4294967.29500 FORMAT "%13.5" ARRAY_SIZE 8 ECU_ADDRESS 0xD0001E7C /end MEASUREMENT
/begin MEASUREMENT te_l "Effective Injection Time for Bank" ULONG t1p0usxms 1 100 0.00 4294967.29500 FORMAT "%13.5" ECU_ADDRESS 0xD0001E9C /end MEASUREMENT
/begin MEASUREMENT thlsuip2_w "" UWORD t_q0p1 1 100 0.00 6553.500 FORMAT "%8.3" ECU_ADDRESS 0xD0000C88 /end MEASUREMENT
/begin MEASUREMENT thlsuip_w "" UWORD t_q0p1 1 100 0.00 6553.500 FORMAT "%8.3" ECU_ADDRESS 0xD0000C8A /end MEASUREMENT
/begin MEASUREMENT ti1a_l "injection-time for the 1st injection pulse" ULONG t_q0p001_ms 1 100 0.00 4294967.29500 FORMAT "%13.5" ARRAY_SIZE 8 ECU_ADDRESS 0xD0001EA0 /end MEASUREMENT
/begin MEASUREMENT ti2a_l "injection-time for the 2nd injection pulse" ULONG t_q0p001_ms 1 100 0.00 4294967.29500 FORMAT "%13.5" ARRAY_SIZE 8 ECU_ADDRESS 0xD0001EC0 /end MEASUREMENT
/begin MEASUREMENT ti3a_l "injection-time for the 3rd injection pulse" ULONG t_q0p001_ms 1 100 0.00 4294967.29500 FORMAT "%13.5" ARRAY_SIZE 8 ECU_ADDRESS 0xD0001EE0 /end MEASUREMENT
/begin MEASUREMENT ti4a_l "injection-time for the 4th injection pulse" ULONG t_q0p001_ms 1 100 0.00 4294967.29500 FORMAT "%13.5" ARRAY_SIZE 8 ECU_ADDRESS 0xD0001F00 /end MEASUREMENT
/begin MEASUREMENT timinnsp_w "Minimum Injection time of post injection at load dynamic" UWORD t_q0p001_ms 1 100 0.00 65.53500 FORMAT "%8.5" ECU_ADDRESS 0xD0001688 /end MEASUREMENT
/begin MEASUREMENT tinspa_l "injection-time post-injection cylinder-individual (array)" ULONG t_q0p001_ms 1 100 0.00 4294967.29500 FORMAT "%13.5" ARRAY_SIZE 8 ECU_ADDRESS 0xD0001F20 /end MEASUREMENT
/begin MEASUREMENT tkerlsu2_w "Temperature of ceramics of LSU, bank 2" UWORD temp_q0p0234_o273 1 100 -273.1500 1262.827 FORMAT "%8.3" ECU_ADDRESS 0xD00015D0 /end MEASUREMENT
/begin MEASUREMENT tkerlsu_w "Temperature of ceramics of LSU" UWORD temp_q0p0234_o273 1 100 -273.1500 1262.827 FORMAT "%8.3" ECU_ADDRESS 0xD00015D2 /end MEASUREMENT
/begin MEASUREMENT tkerlsu_w_flex "" UWORD temp_q0p0234_o273 1 100 -273.1500 1262.827 FORMAT "%8.3" ARRAY_SIZE 2 ECU_ADDRESS 0xD00000EC /end MEASUREMENT
/begin MEASUREMENT tnachl_w "" UWORD t100msxs_uw_b6553p6 1 100 0.00 6553.500 FORMAT "%8.3" ECU_ADDRESS 0xD001ABB4 /end MEASUREMENT
/begin MEASUREMENT tnwia2_l "" ULONG t_q1p024_ms 1 100 0.00 4398046510.08 FORMAT "%13.2" ECU_ADDRESS 0xD0001C44 /end MEASUREMENT
/begin MEASUREMENT tnwia_l "" ULONG t_q1p024_ms 1 100 0.00 4398046510.08 FORMAT "%13.2" ECU_ADDRESS 0xD0001C48 /end MEASUREMENT
/begin MEASUREMENT tnwie2_l "" ULONG t_q1p024_ms 1 100 0.00 4398046510.08 FORMAT "%13.2" ECU_ADDRESS 0xD0001C4C /end MEASUREMENT
/begin MEASUREMENT tnwie_l "" ULONG t_q1p024_ms 1 100 0.00 4398046510.08 FORMAT "%13.2" ECU_ADDRESS 0xD0001C50 /end MEASUREMENT
/begin MEASUREMENT tpes1a_w "Pause time for the 1st injection pulse" SWORD t_q0p001_ms 1 100 -32.76800 32.76700 FORMAT "%8.5" ARRAY_SIZE 8 ECU_ADDRESS 0xD000168A /end MEASUREMENT
/begin MEASUREMENT tpes2a_w "Pause time for the 2nd injection pulse" SWORD t_q0p001_ms 1 100 -32.76800 32.76700 FORMAT "%8.5" ARRAY_SIZE 8 ECU_ADDRESS 0xD000169A /end MEASUREMENT
/begin MEASUREMENT tpes3a_w "Pause time for the 3rd injection pulse" SWORD t_q0p001_ms 1 100 -32.76800 32.76700 FORMAT "%8.5" ARRAY_SIZE 8 ECU_ADDRESS 0xD00016AA /end MEASUREMENT
/begin MEASUREMENT tpes4a_w "Pause time for the 4th injection pulse" SWORD t_q0p001_ms 1 100 -32.76800 32.76700 FORMAT "%8.5" ARRAY_SIZE 8 ECU_ADDRESS 0xD00016BA /end MEASUREMENT
/begin MEASUREMENT TRIIMP_T.timeCounter "" UBYTE t_q0p01 1 100 0.00 2.550 FORMAT "%5.3" ECU_ADDRESS 0xD0000934 /end MEASUREMENT
/begin MEASUREMENT TSC_trqMax "" SWORD Trq 1 100 -3276.800 3276.700 FORMAT "%8.3" ECU_ADDRESS 0xD00000A0 /end MEASUREMENT
/begin MEASUREMENT tseg_l "" ULONG t_q0p0001_ms 1 100 0.00 429496.729500 FORMAT "%13.6" ECU_ADDRESS 0xD0001C54 /end MEASUREMENT
/begin MEASUREMENT tvub_w "delay time of injection valve" UWORD t1p0usxms 1 100 0.00 65.53500 FORMAT "%8.5" ECU_ADDRESS 0xD00016CA /end MEASUREMENT
/begin MEASUREMENT tvzmsv_w "Pull-in phase duration" UWORD t_q0p001_ms 1 100 0.00 65.53500 FORMAT "%8.5" ECU_ADDRESS 0xD0001650 /end MEASUREMENT
/begin MEASUREMENT TWCC_rCtlBalB1 "relative control value balance control" SWORD fak_q3p815Em6 1 100 -0.1250000 0.1249962 FORMAT "%9.7" ECU_ADDRESS 0xD00016CC /end MEASUREMENT
/begin MEASUREMENT TWCC_rCtlBalB2 "relative control value balance control, bank2" SWORD fak_q3p815Em6 1 100 -0.1250000 0.1249962 FORMAT "%9.7" ECU_ADDRESS 0xD00016CE /end MEASUREMENT
/begin MEASUREMENT ua10mn2_w "" UWORD spg_q4p88Em4 1 100 0.00 31.99951 FORMAT "%8.5" ECU_ADDRESS 0xD0000C8C /end MEASUREMENT
/begin MEASUREMENT ua10mn_w "" UWORD spg_q4p88Em4 1 100 0.00 31.99951 FORMAT "%8.5" ECU_ADDRESS 0xD0000C8E /end MEASUREMENT
/begin MEASUREMENT ua10mx2_w "" UWORD spg_q4p88Em4 1 100 0.00 31.99951 FORMAT "%8.5" ECU_ADDRESS 0xD0000C90 /end MEASUREMENT
/begin MEASUREMENT ua10mx_w "" UWORD spg_q4p88Em4 1 100 0.00 31.99951 FORMAT "%8.5" ECU_ADDRESS 0xD0000C92 /end MEASUREMENT
/begin MEASUREMENT uaia2_w "" UWORD spg_q4p88Em4 1 100 0.00 31.99951 FORMAT "%8.5" ECU_ADDRESS 0xD0000C94 /end MEASUREMENT
/begin MEASUREMENT uaiamx2_w "" UWORD spg_q4p88Em4 1 100 0.00 31.99951 FORMAT "%8.5" ECU_ADDRESS 0xD0000C96 /end MEASUREMENT
/begin MEASUREMENT uaiamx_w "" UWORD spg_q4p88Em4 1 100 0.00 31.99951 FORMAT "%8.5" ECU_ADDRESS 0xD0000C98 /end MEASUREMENT
/begin MEASUREMENT uaia_w "" UWORD spg_q4p88Em4 1 100 0.00 31.99951 FORMAT "%8.5" ECU_ADDRESS 0xD0000C9A /end MEASUREMENT
/begin MEASUREMENT ualsu_w_flex "" SWORD spg_q4p88Em4 1 100 -16.00000 15.99951 FORMAT "%8.5" ARRAY_SIZE 2 ECU_ADDRESS 0xD00000AE /end MEASUREMENT
/begin MEASUREMENT UBatt_MV "Ubatt value of the ECU in mV" ULONG OneToOne 1 100 0.00 4294967295.00 FORMAT "%13.2" ECU_ADDRESS 0xD0001E50 /end MEASUREMENT
/begin MEASUREMENT ubsq "battery voltage (on board), conversed to standard quantization" UBYTE spg_q0p1 1 100 0.00 25.50 FORMAT "%5.2" ECU_ADDRESS 0xD0001861 /end MEASUREMENT
/begin MEASUREMENT ubsqf "" UBYTE spg_q0p1 1 100 0.00 25.50 FORMAT "%5.2" ECU_ADDRESS 0xD0001862 /end MEASUREMENT
/begin MEASUREMENT ubsqf_w "Filtered battery voltage" UWORD spg_q0p00039 1 100 0.00 25.59961 FORMAT "%8.5" ECU_ADDRESS 0xD00016D0 /end MEASUREMENT
/begin MEASUREMENT ubsq_w "battery voltage (on board), conversed to standard quantization" UWORD spg_uw_q0p00488_o1 1 100 -1.000000 318.9951 FORMAT "%8.4" ECU_ADDRESS 0xD00016D2 /end MEASUREMENT
/begin MEASUREMENT ugd1ms2_w "" UWORD spg_uw_q0p00488 1 100 0.00 319.9951 FORMAT "%8.4" ARRAY_SIZE 11 ECU_ADDRESS 0xD0000C9C /end MEASUREMENT
/begin MEASUREMENT ugd1ms_w "" UWORD spg_uw_q0p00488 1 100 0.00 319.9951 FORMAT "%8.4" ARRAY_SIZE 11 ECU_ADDRESS 0xD0000CB2 /end MEASUREMENT
/begin MEASUREMENT ulsf1ms2_w "" UWORD spg_uw_q0p00488 1 100 0.00 319.9951 FORMAT "%8.4" ARRAY_SIZE 11 ECU_ADDRESS 0xD0000CC8 /end MEASUREMENT
/begin MEASUREMENT ulsf1ms_w "" UWORD spg_uw_q0p00488 1 100 0.00 319.9951 FORMAT "%8.4" ARRAY_SIZE 11 ECU_ADDRESS 0xD0000CDE /end MEASUREMENT
/begin MEASUREMENT ulsu1ms2_w "" UWORD spg_uw_q0p00488 1 100 0.00 319.9951 FORMAT "%8.4" ARRAY_SIZE 11 ECU_ADDRESS 0xD0000CF4 /end MEASUREMENT
/begin MEASUREMENT ulsu1ms_w "" UWORD spg_uw_q0p00488 1 100 0.00 319.9951 FORMAT "%8.4" ARRAY_SIZE 11 ECU_ADDRESS 0xD0000D0A /end MEASUREMENT
/begin MEASUREMENT uRawAdcLSF1 "" SWORD O2 1 100 -0.3276800 0.3276700 FORMAT "%9.7" ECU_ADDRESS 0xD00000AA /end MEASUREMENT
/begin MEASUREMENT uRawAdcLSF2 "" SWORD O2 1 100 -0.3276800 0.3276700 FORMAT "%9.7" ECU_ADDRESS 0xD00000AC /end MEASUREMENT
/begin MEASUREMENT uRawAdcUA "" UWORD spg_uw_q0p00488 1 100 0.00 319.9951 FORMAT "%8.4" ARRAY_SIZE 2 ECU_ADDRESS 0xD0000100 /end MEASUREMENT
/begin MEASUREMENT uRawAdcUR "" UWORD spg_q0p00488 1 100 0.00 319.9951 FORMAT "%8.4" ARRAY_SIZE 2 ECU_ADDRESS 0xD0000104 /end MEASUREMENT
/begin MEASUREMENT uRawAdcUR_mp "" UWORD spg_q0p00488 1 100 0.00 319.9951 FORMAT "%8.4" ARRAY_SIZE 2 ECU_ADDRESS 0xD0000108 /end MEASUREMENT
/begin MEASUREMENT urfil2_w "" UWORD spg_uw_q0p00488 1 100 0.00 319.9951 FORMAT "%8.4" ECU_ADDRESS 0xD0000D20 /end MEASUREMENT
/begin MEASUREMENT urfil_w "" UWORD spg_uw_q0p00488 1 100 0.00 319.9951 FORMAT "%8.4" ECU_ADDRESS 0xD0000D22 /end MEASUREMENT
/begin MEASUREMENT urflold2_w "" UWORD spg_uw_q0p00488 1 100 0.00 319.9951 FORMAT "%8.4" ARRAY_SIZE 11 ECU_ADDRESS 0xD0000D24 /end MEASUREMENT
/begin MEASUREMENT urflold_w "" UWORD spg_uw_q0p00488 1 100 0.00 319.9951 FORMAT "%8.4" ARRAY_SIZE 11 ECU_ADDRESS 0xD0000D3A /end MEASUREMENT
/begin MEASUREMENT urgddel2_w "" SWORD spg_uw_q0p00488 1 100 -160.0000 159.9951 FORMAT "%8.4" ECU_ADDRESS 0xD0000D50 /end MEASUREMENT
/begin MEASUREMENT urgddel_w "" SWORD spg_uw_q0p00488 1 100 -160.0000 159.9951 FORMAT "%8.4" ECU_ADDRESS 0xD0000D52 /end MEASUREMENT
/begin MEASUREMENT usfk2_w "output voltage oxygen sensor (4.88mV/LSB) downstream front catalyst, bank 2" UWORD spg_uw_q0p00488_o1 1 100 -1.000000 318.9951 FORMAT "%8.4" ECU_ADDRESS 0xD0001590 /end MEASUREMENT
/begin MEASUREMENT usfkslz2_w "Running maximum sensor voltage behind front catalyst, bank 2" UWORD spg_uw_q0p00488_o1 1 100 -1.000000 318.9951 FORMAT "%8.4" ECU_ADDRESS 0xD0000D58 /end MEASUREMENT
/begin MEASUREMENT usfkslz_w "Running maximum sensor voltage behind front catalyst" UWORD spg_uw_q0p00488_o1 1 100 -1.000000 318.9951 FORMAT "%8.4" ECU_ADDRESS 0xD0000D5A /end MEASUREMENT
/begin MEASUREMENT usfk_w "output voltage oxygen sensor (4.88mV/LSB) downstream front catalyst" UWORD spg_uw_q0p00488_o1 1 100 -1.000000 318.9951 FORMAT "%8.4" ECU_ADDRESS 0xD000159A /end MEASUREMENT
/begin MEASUREMENT usflpmn2_w "Running minimum voltage after load pulse, sensor behind front catalyst, bank 2" UWORD spg_q0p00488 1 100 0.00 319.9951 FORMAT "%8.4" ECU_ADDRESS 0xD0000D5C /end MEASUREMENT
/begin MEASUREMENT usflpmn_w "Running minimum voltage after load pulse, sensor behind front catalyst" UWORD spg_q0p00488 1 100 0.00 319.9951 FORMAT "%8.4" ECU_ADDRESS 0xD0000D5E /end MEASUREMENT
/begin MEASUREMENT usflpmx2_w "Running maximum voltage after load pulse, sensor behind front catalyst bank2" UWORD spg_q0p00488 1 100 0.00 319.9951 FORMAT "%8.4" ECU_ADDRESS 0xD0000D60 /end MEASUREMENT
/begin MEASUREMENT usflpmx_w "Running maximum voltage after load pulse, sensor behind front catalyst" UWORD spg_q0p00488 1 100 0.00 319.9951 FORMAT "%8.4" ECU_ADDRESS 0xD0000D62 /end MEASUREMENT
/begin MEASUREMENT ushk2_w "output voltage oxygen sensor (4.88mV/LSB) downstream catalyst 2" UWORD spg_uw_q0p00488_o1 1 100 -1.000000 318.9951 FORMAT "%8.4" ECU_ADDRESS 0xD00015A0 /end MEASUREMENT
/begin MEASUREMENT ushkjsa2 "output voltage oxygen sensor downstream catalyst without offset, DLSSA bank 2" UBYTE spg_q0p005 1 100 0.00 1.275 FORMAT "%5.3" ECU_ADDRESS 0xD0001773 /end MEASUREMENT
/begin MEASUREMENT ushkslz2_w "Running maximum sensor voltage behind catalyst, bank 2" UWORD spg_uw_q0p00488_o1 1 100 -1.000000 318.9951 FORMAT "%8.4" ECU_ADDRESS 0xD0000D64 /end MEASUREMENT
/begin MEASUREMENT ushkslz_w "Running maximum sensor voltage behind catalyst" UWORD spg_uw_q0p00488_o1 1 100 -1.000000 318.9951 FORMAT "%8.4" ECU_ADDRESS 0xD0000D66 /end MEASUREMENT
/begin MEASUREMENT ushk_w "output voltage oxygen sensor (4.88mV/LSB) downstream catalyst" UWORD spg_uw_q0p00488_o1 1 100 -1.000000 318.9951 FORMAT "%8.4" ECU_ADDRESS 0xD00015AA /end MEASUREMENT
/begin MEASUREMENT ushlpmn2_w "Running minimum voltage after load pulse, sensor behind catalyst, bank 2" UWORD spg_q0p00488 1 100 0.00 319.9951 FORMAT "%8.4" ECU_ADDRESS 0xD0000D68 /end MEASUREMENT
/begin MEASUREMENT ushlpmn_w "Running minimum voltage after load pulse, sensor behind catalyst" UWORD spg_q0p00488 1 100 0.00 319.9951 FORMAT "%8.4" ECU_ADDRESS 0xD0000D6A /end MEASUREMENT
/begin MEASUREMENT ushlpmx2_w "Running maximum voltage after load pulse, sensor behind catalyst bank2" UWORD spg_q0p00488 1 100 0.00 319.9951 FORMAT "%8.4" ECU_ADDRESS 0xD0000D6C /end MEASUREMENT
/begin MEASUREMENT ushlpmx_w "Running maximum voltage after load pulse, sensor behind catalyst" UWORD spg_q0p00488 1 100 0.00 319.9951 FORMAT "%8.4" ECU_ADDRESS 0xD0000D6E /end MEASUREMENT
/begin MEASUREMENT usvk2_w "output voltage oxygen sensor (4.88mV/LSB) upstream catalyst 2" UWORD spg_uw_q0p00488_o1 1 100 -1.000000 318.9951 FORMAT "%8.4" ECU_ADDRESS 0xD00015B0 /end MEASUREMENT
/begin MEASUREMENT usvkjsa "output voltage oxygen sensor upstream catalyst without offset, DLSSA" UBYTE spg_q0p005 1 100 0.00 1.275 FORMAT "%5.3" ECU_ADDRESS 0xD0001776 /end MEASUREMENT
/begin MEASUREMENT usvkjsa2 "output voltage oxygen sensor upstream catalyst without offset, DLSSA bank 2" UBYTE spg_q0p005 1 100 0.00 1.275 FORMAT "%5.3" ECU_ADDRESS 0xD0001777 /end MEASUREMENT
/begin MEASUREMENT usvk_w "output voltage oxygen sensor (4.88mV/LSB) upstream catalyst" UWORD spg_uw_q0p00488_o1 1 100 -1.000000 318.9951 FORMAT "%8.4" ECU_ADDRESS 0xD00015B6 /end MEASUREMENT
/begin MEASUREMENT uzkw_w "" UWORD dez 1 100 0.00 65535.00 FORMAT "%8.2" ECU_ADDRESS 0xD0000D8E /end MEASUREMENT
/begin MEASUREMENT VehV_v "" SWORD Vel 1 100 -327.6800 327.6700 FORMAT "%8.4" ECU_ADDRESS 0xD00000A2 /end MEASUREMENT
/begin MEASUREMENT vkrnew "amplifier stage for the next combustion" UBYTE dez 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0001863 /end MEASUREMENT
/begin MEASUREMENT wea "anglemark injection break off" UBYTE kw_q6 1 100 0.00 1530. FORMAT "%5.0" ECU_ADDRESS 0xD0001864 /end MEASUREMENT
/begin MEASUREMENT weea "angle injection end" UBYTE kw_q6 1 100 0.00 1530. FORMAT "%5.0" ARRAY_SIZE 3 ECU_ADDRESS 0xD0001865 /end MEASUREMENT
/begin MEASUREMENT weestsim "Offset angle injection end for simultaneous injections at start" UBYTE kw_q6 1 100 0.00 1530. FORMAT "%5.0" ECU_ADDRESS 0xD0001868 /end MEASUREMENT
/begin MEASUREMENT wes "angle of intake closes" UBYTE kw_q6 1 100 0.00 1530. FORMAT "%5.0" ECU_ADDRESS 0xD0001869 /end MEASUREMENT
/begin MEASUREMENT wesabr "" UBYTE kw_q0p75 1 100 0.00 191.3 FORMAT "%5.1" ECU_ADDRESS 0xD000186A /end MEASUREMENT
/begin MEASUREMENT wesot1a_w "Injection angle with respect to ITDC for the 1st injection pulse" SWORD kw_q0p0234 1 100 -768.0000 767.9766 FORMAT "%8.4" ARRAY_SIZE 8 ECU_ADDRESS 0xD00016D4 /end MEASUREMENT
/begin MEASUREMENT wesot2a_w "Injection angle with respect to ITDC for the 2nd injection pulse" SWORD kw_q0p0234 1 100 -768.0000 767.9766 FORMAT "%8.4" ARRAY_SIZE 8 ECU_ADDRESS 0xD00016E4 /end MEASUREMENT
/begin MEASUREMENT wesot3a_w "Injection angle with respect to ITDC for the 3rd injection pulse" SWORD kw_q0p0234 1 100 -768.0000 767.9766 FORMAT "%8.4" ARRAY_SIZE 8 ECU_ADDRESS 0xD00016F4 /end MEASUREMENT
/begin MEASUREMENT wesot4a_w "Injection angle with respect to ITDC for the 4th injection pulse" SWORD kw_q0p0234 1 100 -768.0000 767.9766 FORMAT "%8.4" ARRAY_SIZE 8 ECU_ADDRESS 0xD0001704 /end MEASUREMENT
/begin MEASUREMENT whzmsv_w "" UWORD kw_q0p1 1 100 0.00 6553.500 FORMAT "%8.3" ECU_ADDRESS 0xD0001648 /end MEASUREMENT
/begin MEASUREMENT wmfa "beginning of measurement window in degree crank angle" UBYTE zw_sb_q0p75 1 100 0.00 191.3 FORMAT "%5.1" ECU_ADDRESS 0xD000186B /end MEASUREMENT
/begin MEASUREMENT wmfaseg "" SWORD kw_sw_q0p0219 1 100 -720.0000 719.9780 FORMAT "%8.4" ECU_ADDRESS 0xD0001714 /end MEASUREMENT
/begin MEASUREMENT wmflcd "length of the measuring window for Complex Driver KnDet" SWORD kw_sw_q0p0219 1 100 -720.0000 719.9780 FORMAT "%8.4" ECU_ADDRESS 0xD0001716 /end MEASUREMENT
/begin MEASUREMENT wnwa2_w "" SWORD kw_q0p0078 1 100 -256.0000 255.9922 FORMAT "%8.4" ECU_ADDRESS 0xD0000D90 /end MEASUREMENT
/begin MEASUREMENT wnwadmna_w "" SWORD kw_q0p0078 1 100 -256.0000 255.9922 FORMAT "%8.4" ECU_ADDRESS 0xD0000D92 /end MEASUREMENT
/begin MEASUREMENT wnwadmne_w "" SWORD kw_q0p0078 1 100 -256.0000 255.9922 FORMAT "%8.4" ECU_ADDRESS 0xD0000D94 /end MEASUREMENT
/begin MEASUREMENT wnwadmxa_w "" SWORD kw_q0p0078 1 100 -256.0000 255.9922 FORMAT "%8.4" ECU_ADDRESS 0xD0000D96 /end MEASUREMENT
/begin MEASUREMENT wnwadmxe_w "" SWORD kw_q0p0078 1 100 -256.0000 255.9922 FORMAT "%8.4" ECU_ADDRESS 0xD0000D98 /end MEASUREMENT
/begin MEASUREMENT wnwa_w "" SWORD kw_q0p0078 1 100 -256.0000 255.9922 FORMAT "%8.4" ECU_ADDRESS 0xD0000D9A /end MEASUREMENT
/begin MEASUREMENT wnwe2_w "" SWORD kw_q0p0078 1 100 -256.0000 255.9922 FORMAT "%8.4" ECU_ADDRESS 0xD0000D9C /end MEASUREMENT
/begin MEASUREMENT wnwe_w "" SWORD kw_q0p0078 1 100 -256.0000 255.9922 FORMAT "%8.4" ECU_ADDRESS 0xD0000D9E /end MEASUREMENT
/begin MEASUREMENT wnwkwa2_w "" UWORD kw_q0p1 1 100 0.00 6553.500 FORMAT "%8.3" ECU_ADDRESS 0xD0000DA0 /end MEASUREMENT
/begin MEASUREMENT wnwkwa_w "" UWORD kw_q0p1 1 100 0.00 6553.500 FORMAT "%8.3" ECU_ADDRESS 0xD0000DA2 /end MEASUREMENT
/begin MEASUREMENT wnwkwe2_w "" UWORD kw_q0p1 1 100 0.00 6553.500 FORMAT "%8.3" ECU_ADDRESS 0xD0000DA4 /end MEASUREMENT
/begin MEASUREMENT wnwkwe_w "" UWORD kw_q0p1 1 100 0.00 6553.500 FORMAT "%8.3" ECU_ADDRESS 0xD0000DA6 /end MEASUREMENT
/begin MEASUREMENT wuccnt "" UBYTE dez 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD000173F /end MEASUREMENT
/begin MEASUREMENT wvzmsv_w "" UWORD kw_q0p1 1 100 0.00 6553.500 FORMAT "%8.3" ECU_ADDRESS 0xD000164A /end MEASUREMENT
/begin MEASUREMENT zlamko "Number of the lambda request determining the lambda setpoint" UBYTE dez 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD000186C /end MEASUREMENT
/begin MEASUREMENT zlamko2 "Number of the lambda request determining the lambda setpoint, bank 2" UBYTE dez 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD000186D /end MEASUREMENT
/begin MEASUREMENT zphfl "" SBYTE dez 1 100 -128.0 127.0 FORMAT "%5.1" ECU_ADDRESS 0xD000174C /end MEASUREMENT
/begin MEASUREMENT zphfl2 "" SBYTE dez 1 100 -128.0 127.0 FORMAT "%5.1" ECU_ADDRESS 0xD000174D /end MEASUREMENT
/begin MEASUREMENT zphfl3 "" SBYTE dez 1 100 -128.0 127.0 FORMAT "%5.1" ECU_ADDRESS 0xD000174E /end MEASUREMENT
/begin MEASUREMENT zphfl4 "" SBYTE dez 1 100 -128.0 127.0 FORMAT "%5.1" ECU_ADDRESS 0xD000174F /end MEASUREMENT
/begin MEASUREMENT zrph2_l "" ULONG dez 1 100 0.00 4294967295.00 FORMAT "%13.2" ECU_ADDRESS 0xD0001C58 /end MEASUREMENT
/begin MEASUREMENT zrph3_l "" ULONG dez 1 100 0.00 4294967295.00 FORMAT "%13.2" ECU_ADDRESS 0xD0001C5C /end MEASUREMENT
/begin MEASUREMENT zrph4_l "" ULONG dez 1 100 0.00 4294967295.00 FORMAT "%13.2" ECU_ADDRESS 0xD0001C60 /end MEASUREMENT
/begin MEASUREMENT zrph_l "" ULONG dez 1 100 0.00 4294967295.00 FORMAT "%13.2" ECU_ADDRESS 0xD0001C64 /end MEASUREMENT
/begin MEASUREMENT zwcalcar "ignition angle output array" SBYTE zw_sb_q0p75 1 100 -96.00 95.25 FORMAT "%5.2" ARRAY_SIZE 8 ECU_ADDRESS 0xD000186E /end MEASUREMENT
/begin MEASUREMENT zzaehl "Ignition counter" UBYTE dez 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD00018A0 /end MEASUREMENT
/begin MEASUREMENT zzaehl_w "Ignition counter" UWORD dez 1 100 0.00 65535.00 FORMAT "%8.2" ECU_ADDRESS 0xD0001894 /end MEASUREMENT
/begin MEASUREMENT zzkwas_w "" UWORD dez 1 100 0.00 65535.00 FORMAT "%8.2" ECU_ADDRESS 0xD0000DA8 /end MEASUREMENT
/begin MEASUREMENT zzyl "" UBYTE dez 1 100 0.00 11.00 FORMAT "%5.2" ECU_ADDRESS 0xD0001750 /end MEASUREMENT
/begin MEASUREMENT zzylbi "" UBYTE dez 1 100 0.00 11.00 FORMAT "%5.2" ECU_ADDRESS 0xD0001751 /end MEASUREMENT
/begin MEASUREMENT zzylzue "" UBYTE dez 1 100 0.00 255.0 FORMAT "%5.1" ECU_ADDRESS 0xD0001876 /end MEASUREMENT
/begin MEASUREMENT zzylzuear "" UBYTE dez 1 100 0.00 255.0 FORMAT "%5.1" ARRAY_SIZE 2 ECU_ADDRESS 0xD0001877 /end MEASUREMENT
/begin MEASUREMENT dummy_stMainRelais "" UBYTE ident 1 100 -9.9999999999999995e+36 9.9999999999999995e+36 ECU_ADDRESS 0xd00069a2 /end MEASUREMENT
/begin MEASUREMENT Cpc_pChargeFilt "" UWORD fac_2048 1 100 0 262140 ECU_ADDRESS 0xd0006930 /end MEASUREMENT
/begin MEASUREMENT Eih_flgInputError "" UBYTE ident 1 100 -9.9999999999999995e+36 9.9999999999999995e+36 ECU_ADDRESS 0xd00069bc /end MEASUREMENT
/begin MEASUREMENT Eoh_flgOutputError "" UBYTE ident 1 100 -9.9999999999999995e+36 9.9999999999999995e+36 ECU_ADDRESS 0xd00069bb /end MEASUREMENT
/begin MEASUREMENT Amf_facRelAir "" UWORD fac_512 1 100 0 2.5 ECU_ADDRESS 0xd000694c /end MEASUREMENT
/begin MEASUREMENT Itc_tiInjOffset "" SWORD ident 1 100 -10000 10000 ECU_ADDRESS 0xd0006900 /end MEASUREMENT
/begin MEASUREMENT Iac_flgIgnCutoff "" UBYTE ident 1 100 -9.9999999999999995e+36 9.9999999999999995e+36 ECU_ADDRESS 0xd00069b1 /end MEASUREMENT
/begin MEASUREMENT T2t_facWasteGateRate "" UWORD fac_10000 1 100 0.01 0.98999999999999999 ECU_ADDRESS 0xd00068ca /end MEASUREMENT
/begin MEASUREMENT dummy_stIntercooler "" UBYTE ident 1 100 -9.9999999999999995e+36 9.9999999999999995e+36 ECU_ADDRESS 0xd00069d7 /end MEASUREMENT
/begin MEASUREMENT dummy_stMainRelais "" UBYTE ident 1 100 -9.9999999999999995e+36 9.9999999999999995e+36 ECU_ADDRESS 0xd00069a2 /end MEASUREMENT
/begin MEASUREMENT Stc_stStarter "" UBYTE ident 1 100 -9.9999999999999995e+36 9.9999999999999995e+36 ECU_ADDRESS 0xd0006978 /end MEASUREMENT
/begin MEASUREMENT Isc_facCtrl "" SWORD fac_2 1 100 -16384 16383.5 ECU_ADDRESS 0xd000692a /end MEASUREMENT
/begin MEASUREMENT T2t_degIgnAngle "" SBYTE IGN_4div3 1 100 -96 95.25 ECU_ADDRESS 0xd00069a4 /end MEASUREMENT
/begin MEASUREMENT T2t_Req2pManiReqBase "" UWORD fac_1024 1 100 0.0009765625 1 ECU_ADDRESS 0xd00068f8 /end MEASUREMENT
/begin MEASUREMENT Stc_Counter "" UBYTE fac_2 1 100 0 40 ECU_ADDRESS 0xd00069ae /end MEASUREMENT
/begin COMPU_METHOD AngleCrS "" RAT_FUNC "%6.4" "deg CrS" COEFFS 0 45.5111111111 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD B_TRUE "" TAB_VERB "%6.3" "" COMPU_TAB_REF B_TRUE /end COMPU_METHOD
/begin COMPU_VTAB B_TRUE "" TAB_VERB 2 0 "----" 1 "TRUE" /end COMPU_VTAB
/begin COMPU_METHOD dez "" RAT_FUNC "%6.2" "" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD ESC_MACHINE_TICKS_TO_US "" RAT_FUNC "%6.4" "us" COEFFS 0 90 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD ExeCon_State_01 "" TAB_VERB "%6.3" "" COMPU_TAB_REF ExeCon_State_01 /end COMPU_METHOD
/begin COMPU_VTAB ExeCon_State_01 "" TAB_VERB 4 0 "SYC_BOOT" 1 "SYC_PROC_INIT" 2 "SYC_PROC_EXEC" 3 "SYC_SHUTDOWN" /end COMPU_VTAB
/begin COMPU_METHOD ExeCon_State_02 "" TAB_VERB "%6.3" "" COMPU_TAB_REF ExeCon_State_02 /end COMPU_METHOD
/begin COMPU_VTAB ExeCon_State_02 "" TAB_VERB 7 0 "SYC_INI" 1 "SYC_INISYN" 2 "SYC_INIEND" 3 "SYC_PREDRIVE" 4 "SYC_DRIVE" 5 "SYC_POSTDRIVE" 6 "SYC_POST_OS_EXIT" /end COMPU_VTAB
/begin COMPU_METHOD fak_q0p000244 "" RAT_FUNC "%6.5" "-" COEFFS 0 65536 0 0 0 16 /end COMPU_METHOD
/begin COMPU_METHOD fak_q0p01 "" RAT_FUNC "%6.4" "" COEFFS 0 100 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD fak_q3p815Em6 "" RAT_FUNC "%8.7" "-" COEFFS 0 65536 0 0 0 0.25 /end COMPU_METHOD
/begin COMPU_METHOD fak_uw_b16 "" RAT_FUNC "%6.5" "-" COEFFS 0 65536 0 0 0 16 /end COMPU_METHOD
/begin COMPU_METHOD fak_uw_b2 "" RAT_FUNC "%7.6" "-" COEFFS 0 65536 0 0 0 2 /end COMPU_METHOD
/begin COMPU_METHOD injdd_InjTypeFuelMode_State_t "" TAB_VERB "%6.3" "" COMPU_TAB_REF injdd_InjTypeFuelMode_State_t /end COMPU_METHOD
/begin COMPU_VTAB injdd_InjTypeFuelMode_State_t "" TAB_VERB 2 0 "INJ_TYPE_GDI" 1 "INJ_TYPE_GPFI" /end COMPU_VTAB
/begin COMPU_METHOD i_q1_uA "" RAT_FUNC "%6.2" "uA" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD kw_q0p0078 "" RAT_FUNC "%6.4" "Grad KW" COEFFS 0 128 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD kw_q0p0234 "" RAT_FUNC "%6.4" "Grad KW" COEFFS 0 32768 0 0 0 768 /end COMPU_METHOD
/begin COMPU_METHOD kw_q0p1 "" RAT_FUNC "%6.3" "Grad KW" COEFFS 0 10 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD kw_q0p75 "" RAT_FUNC "%6.3" "Grad KW" COEFFS 0 4 0 0 0 3 /end COMPU_METHOD
/begin COMPU_METHOD kw_q6 "" RAT_FUNC "%6.2" "Grad KW" COEFFS 0 1 0 0 0 6 /end COMPU_METHOD
/begin COMPU_METHOD kw_sw_q0p0219 "" RAT_FUNC "%6.4" "Grad KW" COEFFS 0 32768 0 0 0 720 /end COMPU_METHOD
/begin COMPU_METHOD lambda "" RAT_FUNC "%6.5" "-" COEFFS 0 1000 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD lambdaRecVal "" RAT_FUNC "%6.5" "-" COEFFS 0 1000 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD Length "" RAT_FUNC "%6.2" "m" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD MILLmp_ReqVerb "" TAB_VERB "%6.3" "" COMPU_TAB_REF MILLmp_ReqVerb /end COMPU_METHOD
/begin COMPU_VTAB MILLmp_ReqVerb "" TAB_VERB 256 0 "---|---|---|---|---|---|---|---" 1 "---|---|---|---|---|---|---|FES" 2 "---|---|---|---|---|---|DMD|---" 3 "---|---|---|---|---|---|DMD|FES" 4 "---|---|---|---|---|TRA|---|---" 5 "---|---|---|---|---|TRA|---|FES" 6 "---|---|---|---|---|TRA|DMD|---" 7 "---|---|---|---|---|TRA|DMD|FES" 8 "---|---|---|---|ECU1|---|---|---" 9 "---|---|---|---|ECU1|---|---|FES" 10 "---|---|---|---|ECU1|---|DMD|---" 11 "---|---|---|---|ECU1|---|DMD|FES" 12 "---|---|---|---|ECU1|TRA|---|---" 13 "---|---|---|---|ECU1|TRA|---|FES" 14 "---|---|---|---|ECU1|TRA|DMD|---" 15 "---|---|---|---|ECU1|TRA|DMD|FES" 16 "---|---|---|ECU2|---|---|---|---" 17 "---|---|---|ECU2|---|---|---|FES" 18 "---|---|---|ECU2|---|---|DMD|---" 19 "---|---|---|ECU2|---|---|DMD|FES" 20 "---|---|---|ECU2|---|TRA|---|---" 21 "---|---|---|ECU2|---|TRA|---|FES" 22 "---|---|---|ECU2|---|TRA|DMD|---" 23 "---|---|---|ECU2|---|TRA|DMD|FES" 24 "---|---|---|ECU2|ECU1|---|---|---" 25 "---|---|---|ECU2|ECU1|---|---|FES" 26 "---|---|---|ECU2|ECU1|---|DMD|---" 27 "---|---|---|ECU2|ECU1|---|DMD|FES" 28 "---|---|---|ECU2|ECU1|TRA|---|---" 29 "---|---|---|ECU2|ECU1|TRA|---|FES" 30 "---|---|---|ECU2|ECU1|TRA|DMD|---" 31 "---|---|---|ECU2|ECU1|TRA|DMD|FES" 32 "---|---|ECU3|---|---|---|---|---" 33 "---|---|ECU3|---|---|---|---|FES" 34 "---|---|ECU3|---|---|---|DMD|---" 35 "---|---|ECU3|---|---|---|DMD|FES" 36 "---|---|ECU3|---|---|TRA|---|---" 37 "---|---|ECU3|---|---|TRA|---|FES" 38 "---|---|ECU3|---|---|TRA|DMD|---" 39 "---|---|ECU3|---|---|TRA|DMD|FES" 40 "---|---|ECU3|---|ECU1|---|---|---" 41 "---|---|ECU3|---|ECU1|---|---|FES" 42 "---|---|ECU3|---|ECU1|---|DMD|---" 43 "---|---|ECU3|---|ECU1|---|DMD|FES" 44 "---|---|ECU3|---|ECU1|TRA|---|---" 45 "---|---|ECU3|---|ECU1|TRA|---|FES" 46 "---|---|ECU3|---|ECU1|TRA|DMD|---" 47 "---|---|ECU3|---|ECU1|TRA|DMD|FES" 48 "---|---|ECU3|ECU2|---|---|---|---" 49 "---|---|ECU3|ECU2|---|---|---|FES" 50 "---|---|ECU3|ECU2|---|---|DMD|---" 51 "---|---|ECU3|ECU2|---|---|DMD|FES" 52 "---|---|ECU3|ECU2|---|TRA|---|---" 53 "---|---|ECU3|ECU2|---|TRA|---|FES" 54 "---|---|ECU3|ECU2|---|TRA|DMD|---" 55 "---|---|ECU3|ECU2|---|TRA|DMD|FES" 56 "---|---|ECU3|ECU2|ECU1|---|---|---" 57 "---|---|ECU3|ECU2|ECU1|---|---|FES" 58 "---|---|ECU3|ECU2|ECU1|---|DMD|---" 59 "---|---|ECU3|ECU2|ECU1|---|DMD|FES" 60 "---|---|ECU3|ECU2|ECU1|TRA|---|---" 61 "---|---|ECU3|ECU2|ECU1|TRA|---|FES" 62 "---|---|ECU3|ECU2|ECU1|TRA|DMD|---" 63 "---|---|ECU3|ECU2|ECU1|TRA|DMD|FES" 64 "---|ECU4|---|---|---|---|---|---" 65 "---|ECU4|---|---|---|---|---|FES" 66 "---|ECU4|---|---|---|---|DMD|---" 67 "---|ECU4|---|---|---|---|DMD|FES" 68 "---|ECU4|---|---|---|TRA|---|---" 69 "---|ECU4|---|---|---|TRA|---|FES" 70 "---|ECU4|---|---|---|TRA|DMD|---" 71 "---|ECU4|---|---|---|TRA|DMD|FES" 72 "---|ECU4|---|---|ECU1|---|---|---" 73 "---|ECU4|---|---|ECU1|---|---|FES" 74 "---|ECU4|---|---|ECU1|---|DMD|---" 75 "---|ECU4|---|---|ECU1|---|DMD|FES" 76 "---|ECU4|---|---|ECU1|TRA|---|---" 77 "---|ECU4|---|---|ECU1|TRA|---|FES" 78 "---|ECU4|---|---|ECU1|TRA|DMD|---" 79 "---|ECU4|---|---|ECU1|TRA|DMD|FES" 80 "---|ECU4|---|ECU2|---|---|---|---" 81 "---|ECU4|---|ECU2|---|---|---|FES" 82 "---|ECU4|---|ECU2|---|---|DMD|---" 83 "---|ECU4|---|ECU2|---|---|DMD|FES" 84 "---|ECU4|---|ECU2|---|TRA|---|---" 85 "---|ECU4|---|ECU2|---|TRA|---|FES" 86 "---|ECU4|---|ECU2|---|TRA|DMD|---" 87 "---|ECU4|---|ECU2|---|TRA|DMD|FES" 88 "---|ECU4|---|ECU2|ECU1|---|---|---" 89 "---|ECU4|---|ECU2|ECU1|---|---|FES" 90 "---|ECU4|---|ECU2|ECU1|---|DMD|---" 91 "---|ECU4|---|ECU2|ECU1|---|DMD|FES" 92 "---|ECU4|---|ECU2|ECU1|TRA|---|---" 93 "---|ECU4|---|ECU2|ECU1|TRA|---|FES" 94 "---|ECU4|---|ECU2|ECU1|TRA|DMD|---" 95 "---|ECU4|---|ECU2|ECU1|TRA|DMD|FES" 96 "---|ECU4|ECU3|---|---|---|---|---" 97 "---|ECU4|ECU3|---|---|---|---|FES" 98 "---|ECU4|ECU3|---|---|---|DMD|---" 99 "---|ECU4|ECU3|---|---|---|DMD|FES" 100 "---|ECU4|ECU3|---|---|TRA|---|---" 101 "---|ECU4|ECU3|---|---|TRA|---|FES" 102 "---|ECU4|ECU3|---|---|TRA|DMD|---" 103 "---|ECU4|ECU3|---|---|TRA|DMD|FES" 104 "---|ECU4|ECU3|---|ECU1|---|---|---" 105 "---|ECU4|ECU3|---|ECU1|---|---|FES" 106 "---|ECU4|ECU3|---|ECU1|---|DMD|---" 107 "---|ECU4|ECU3|---|ECU1|---|DMD|FES" 108 "---|ECU4|ECU3|---|ECU1|TRA|---|---" 109 "---|ECU4|ECU3|---|ECU1|TRA|---|FES" 110 "---|ECU4|ECU3|---|ECU1|TRA|DMD|---" 111 "---|ECU4|ECU3|---|ECU1|TRA|DMD|FES" 112 "---|ECU4|ECU3|ECU2|---|---|---|---" 113 "---|ECU4|ECU3|ECU2|---|---|---|FES" 114 "---|ECU4|ECU3|ECU2|---|---|DMD|---" 115 "---|ECU4|ECU3|ECU2|---|---|DMD|FES" 116 "---|ECU4|ECU3|ECU2|---|TRA|---|---" 117 "---|ECU4|ECU3|ECU2|---|TRA|---|FES" 118 "---|ECU4|ECU3|ECU2|---|TRA|DMD|---" 119 "---|ECU4|ECU3|ECU2|---|TRA|DMD|FES" 120 "---|ECU4|ECU3|ECU2|ECU1|---|---|---" 121 "---|ECU4|ECU3|ECU2|ECU1|---|---|FES" 122 "---|ECU4|ECU3|ECU2|ECU1|---|DMD|---" 123 "---|ECU4|ECU3|ECU2|ECU1|---|DMD|FES" 124 "---|ECU4|ECU3|ECU2|ECU1|TRA|---|---" 125 "---|ECU4|ECU3|ECU2|ECU1|TRA|---|FES" 126 "---|ECU4|ECU3|ECU2|ECU1|TRA|DMD|---" 127 "---|ECU4|ECU3|ECU2|ECU1|TRA|DMD|FES" 128 "SLV|---|---|---|---|---|---|---" 129 "SLV|---|---|---|---|---|---|FES" 130 "SLV|---|---|---|---|---|DMD|---" 131 "SLV|---|---|---|---|---|DMD|FES" 132 "SLV|---|---|---|---|TRA|---|---" 133 "SLV|---|---|---|---|TRA|---|FES" 134 "SLV|---|---|---|---|TRA|DMD|---" 135 "SLV|---|---|---|---|TRA|DMD|FES" 136 "SLV|---|---|---|ECU1|---|---|---" 137 "SLV|---|---|---|ECU1|---|---|FES" 138 "SLV|---|---|---|ECU1|---|DMD|---" 139 "SLV|---|---|---|ECU1|---|DMD|FES" 140 "SLV|---|---|---|ECU1|TRA|---|---" 141 "SLV|---|---|---|ECU1|TRA|---|FES" 142 "SLV|---|---|---|ECU1|TRA|DMD|---" 143 "SLV|---|---|---|ECU1|TRA|DMD|FES" 144 "SLV|---|---|ECU2|---|---|---|---" 145 "SLV|---|---|ECU2|---|---|---|FES" 146 "SLV|---|---|ECU2|---|---|DMD|---" 147 "SLV|---|---|ECU2|---|---|DMD|FES" 148 "SLV|---|---|ECU2|---|TRA|---|---" 149 "SLV|---|---|ECU2|---|TRA|---|FES" 150 "SLV|---|---|ECU2|---|TRA|DMD|---" 151 "SLV|---|---|ECU2|---|TRA|DMD|FES" 152 "SLV|---|---|ECU2|ECU1|---|---|---" 153 "SLV|---|---|ECU2|ECU1|---|---|FES" 154 "SLV|---|---|ECU2|ECU1|---|DMD|---" 155 "SLV|---|---|ECU2|ECU1|---|DMD|FES" 156 "SLV|---|---|ECU2|ECU1|TRA|---|---" 157 "SLV|---|---|ECU2|ECU1|TRA|---|FES" 158 "SLV|---|---|ECU2|ECU1|TRA|DMD|---" 159 "SLV|---|---|ECU2|ECU1|TRA|DMD|FES" 160 "SLV|---|ECU3|---|---|---|---|---" 161 "SLV|---|ECU3|---|---|---|---|FES" 162 "SLV|---|ECU3|---|---|---|DMD|---" 163 "SLV|---|ECU3|---|---|---|DMD|FES" 164 "SLV|---|ECU3|---|---|TRA|---|---" 165 "SLV|---|ECU3|---|---|TRA|---|FES" 166 "SLV|---|ECU3|---|---|TRA|DMD|---" 167 "SLV|---|ECU3|---|---|TRA|DMD|FES" 168 "SLV|---|ECU3|---|ECU1|---|---|---" 169 "SLV|---|ECU3|---|ECU1|---|---|FES" 170 "SLV|---|ECU3|---|ECU1|---|DMD|---" 171 "SLV|---|ECU3|---|ECU1|---|DMD|FES" 172 "SLV|---|ECU3|---|ECU1|TRA|---|---" 173 "SLV|---|ECU3|---|ECU1|TRA|---|FES" 174 "SLV|---|ECU3|---|ECU1|TRA|DMD|---" 175 "SLV|---|ECU3|---|ECU1|TRA|DMD|FES" 176 "SLV|---|ECU3|ECU2|---|---|---|---" 177 "SLV|---|ECU3|ECU2|---|---|---|FES" 178 "SLV|---|ECU3|ECU2|---|---|DMD|---" 179 "SLV|---|ECU3|ECU2|---|---|DMD|FES" 180 "SLV|---|ECU3|ECU2|---|TRA|---|---" 181 "SLV|---|ECU3|ECU2|---|TRA|---|FES" 182 "SLV|---|ECU3|ECU2|---|TRA|DMD|---" 183 "SLV|---|ECU3|ECU2|---|TRA|DMD|FES" 184 "SLV|---|ECU3|ECU2|ECU1|---|---|---" 185 "SLV|---|ECU3|ECU2|ECU1|---|---|FES" 186 "SLV|---|ECU3|ECU2|ECU1|---|DMD|---" 187 "SLV|---|ECU3|ECU2|ECU1|---|DMD|FES" 188 "SLV|---|ECU3|ECU2|ECU1|TRA|---|---" 189 "SLV|---|ECU3|ECU2|ECU1|TRA|---|FES" 190 "SLV|---|ECU3|ECU2|ECU1|TRA|DMD|---" 191 "SLV|---|ECU3|ECU2|ECU1|TRA|DMD|FES" 192 "SLV|ECU4|---|---|---|---|---|---" 193 "SLV|ECU4|---|---|---|---|---|FES" 194 "SLV|ECU4|---|---|---|---|DMD|---" 195 "SLV|ECU4|---|---|---|---|DMD|FES" 196 "SLV|ECU4|---|---|---|TRA|---|---" 197 "SLV|ECU4|---|---|---|TRA|---|FES" 198 "SLV|ECU4|---|---|---|TRA|DMD|---" 199 "SLV|ECU4|---|---|---|TRA|DMD|FES" 200 "SLV|ECU4|---|---|ECU1|---|---|---" 201 "SLV|ECU4|---|---|ECU1|---|---|FES" 202 "SLV|ECU4|---|---|ECU1|---|DMD|---" 203 "SLV|ECU4|---|---|ECU1|---|DMD|FES" 204 "SLV|ECU4|---|---|ECU1|TRA|---|---" 205 "SLV|ECU4|---|---|ECU1|TRA|---|FES" 206 "SLV|ECU4|---|---|ECU1|TRA|DMD|---" 207 "SLV|ECU4|---|---|ECU1|TRA|DMD|FES" 208 "SLV|ECU4|---|ECU2|---|---|---|---" 209 "SLV|ECU4|---|ECU2|---|---|---|FES" 210 "SLV|ECU4|---|ECU2|---|---|DMD|---" 211 "SLV|ECU4|---|ECU2|---|---|DMD|FES" 212 "SLV|ECU4|---|ECU2|---|TRA|---|---" 213 "SLV|ECU4|---|ECU2|---|TRA|---|FES" 214 "SLV|ECU4|---|ECU2|---|TRA|DMD|---" 215 "SLV|ECU4|---|ECU2|---|TRA|DMD|FES" 216 "SLV|ECU4|---|ECU2|ECU1|---|---|---" 217 "SLV|ECU4|---|ECU2|ECU1|---|---|FES" 218 "SLV|ECU4|---|ECU2|ECU1|---|DMD|---" 219 "SLV|ECU4|---|ECU2|ECU1|---|DMD|FES" 220 "SLV|ECU4|---|ECU2|ECU1|TRA|---|---" 221 "SLV|ECU4|---|ECU2|ECU1|TRA|---|FES" 222 "SLV|ECU4|---|ECU2|ECU1|TRA|DMD|---" 223 "SLV|ECU4|---|ECU2|ECU1|TRA|DMD|FES" 224 "SLV|ECU4|ECU3|---|---|---|---|---" 225 "SLV|ECU4|ECU3|---|---|---|---|FES" 226 "SLV|ECU4|ECU3|---|---|---|DMD|---" 227 "SLV|ECU4|ECU3|---|---|---|DMD|FES" 228 "SLV|ECU4|ECU3|---|---|TRA|---|---" 229 "SLV|ECU4|ECU3|---|---|TRA|---|FES" 230 "SLV|ECU4|ECU3|---|---|TRA|DMD|---" 231 "SLV|ECU4|ECU3|---|---|TRA|DMD|FES" 232 "SLV|ECU4|ECU3|---|ECU1|---|---|---" 233 "SLV|ECU4|ECU3|---|ECU1|---|---|FES" 234 "SLV|ECU4|ECU3|---|ECU1|---|DMD|---" 235 "SLV|ECU4|ECU3|---|ECU1|---|DMD|FES" 236 "SLV|ECU4|ECU3|---|ECU1|TRA|---|---" 237 "SLV|ECU4|ECU3|---|ECU1|TRA|---|FES" 238 "SLV|ECU4|ECU3|---|ECU1|TRA|DMD|---" 239 "SLV|ECU4|ECU3|---|ECU1|TRA|DMD|FES" 240 "SLV|ECU4|ECU3|ECU2|---|---|---|---" 241 "SLV|ECU4|ECU3|ECU2|---|---|---|FES" 242 "SLV|ECU4|ECU3|ECU2|---|---|DMD|---" 243 "SLV|ECU4|ECU3|ECU2|---|---|DMD|FES" 244 "SLV|ECU4|ECU3|ECU2|---|TRA|---|---" 245 "SLV|ECU4|ECU3|ECU2|---|TRA|---|FES" 246 "SLV|ECU4|ECU3|ECU2|---|TRA|DMD|---" 247 "SLV|ECU4|ECU3|ECU2|---|TRA|DMD|FES" 248 "SLV|ECU4|ECU3|ECU2|ECU1|---|---|---" 249 "SLV|ECU4|ECU3|ECU2|ECU1|---|---|FES" 250 "SLV|ECU4|ECU3|ECU2|ECU1|---|DMD|---" 251 "SLV|ECU4|ECU3|ECU2|ECU1|---|DMD|FES" 252 "SLV|ECU4|ECU3|ECU2|ECU1|TRA|---|---" 253 "SLV|ECU4|ECU3|ECU2|ECU1|TRA|---|FES" 254 "SLV|ECU4|ECU3|ECU2|ECU1|TRA|DMD|---" 255 "SLV|ECU4|ECU3|ECU2|ECU1|TRA|DMD|FES" /end COMPU_VTAB
/begin COMPU_METHOD MILLmp_StVerb "" TAB_VERB "%6.3" "" COMPU_TAB_REF MILLmp_StVerb /end COMPU_METHOD
/begin COMPU_VTAB MILLmp_StVerb "" TAB_VERB 5 17 "PreStart_VisTest" 33 "PreStart_RdnBln" 65 "PreStart_WaitForStart" 2 "AfterStart" 4 "Cruising" /end COMPU_VTAB
/begin COMPU_METHOD Mo_trq_nm_q0p1 "" RAT_FUNC "%6.3" "Nm" COEFFS 0 10 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD m_q2p777Em5_kg "" RAT_FUNC "%7.6" "kg" COEFFS 0 3600 0 0 0 0.1 /end COMPU_METHOD
/begin COMPU_METHOD m_uw_b6553p5 "" RAT_FUNC "%6.3" "kg/h" COEFFS 0 1 0 0 0 0.1 /end COMPU_METHOD
/begin COMPU_METHOD nmotg_sb_q100 "" RAT_FUNC "%6.0" "1/(min*s)" COEFFS 0 1 0 0 0 100 /end COMPU_METHOD
/begin COMPU_METHOD nmotg_sw_q0p39 "" RAT_FUNC "%6.3" "1/(min*s)" COEFFS 0 1 0 0 0 0.39063 /end COMPU_METHOD
/begin COMPU_METHOD nmot_q10 "" RAT_FUNC "%6.1" "1/min" COEFFS 0 1 0 0 0 10 /end COMPU_METHOD
/begin COMPU_METHOD nmot_ub_q10 "" RAT_FUNC "%6.1" "1/min" COEFFS 0 1 0 0 0 10 /end COMPU_METHOD
/begin COMPU_METHOD nmot_uw_q0p25 "" RAT_FUNC "%6.3" "1/min" COEFFS 0 1 0 0 0 0.25 /end COMPU_METHOD
/begin COMPU_METHOD O2 "" RAT_FUNC "%8.7" "-" COEFFS 0 100000 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD OneToOne "" RAT_FUNC "%6.2" "No Unit" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD OneToOne_ms "" RAT_FUNC "%6.2" "ms" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD OneToTenCarb "" RAT_FUNC "%6.1" "-" COEFFS 0 0.1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD p_q0p0005 "" RAT_FUNC "%6.5" "MPa" COEFFS 0 10000 0 0 0 5 /end COMPU_METHOD
/begin COMPU_METHOD Reset_GrpID "" TAB_VERB "%6.3" "" COMPU_TAB_REF Reset_GrpID /end COMPU_METHOD
/begin COMPU_VTAB Reset_GrpID "" TAB_VERB 27 0 "SWRESET_GRP_POWERON_E" 1 "SWRESET_GRP_HWRESET_E" 2 "SWRESET_GRP_WDT_E" 3 "SWRESET_GRP_WAKEUP_E" 4 "SWRESET_GRP_TRAP_E" 5 "SWRESET_GRP_SB_E" 6 "SWRESET_GRP_CB_E" 7 "SWRESET_SOFTRESETGRP_E" 8 "SWRESET_GRP_DUMMY_01" 9 "SWRESET_GRP_DUMMY_02" 10 "SWRESET_GRP_SYC_KL15RST_E" 11 "RESET_SWRESET_ASW_01" 12 "RESET_CANGRP_E" 13 "RESET_EEP_GRP_E" 14 "RESET_SWRESET_EPM_E" 15 "RESET_SWRESET_ESC_E" 16 "RESET_EXECON_GRP_E" 17 "RESET_SWRESET_OS_01" 18 "RESET_HWEMONGRP_E" 19 "RESET_ERRINTRGRP_E" 20 "SWRESET_SYCGRP_E" 21 "RESET_SWRESET_TPROT" 22 "SWRESET_UNSUPPORTED_CPU_E" 23 "RESET_ADCI_E" 24 "RESET_DMA_E" 25 "RESET_FLASH_E" 26 "SWRESET_PCP_GRP_E" /end COMPU_VTAB
/begin COMPU_METHOD Reset_ID "" TAB_VERB "%6.3" "" COMPU_TAB_REF Reset_ID /end COMPU_METHOD
/begin COMPU_VTAB Reset_ID "" TAB_VERB 118 0 "SWRESET_POWERON_E" 1 "SWRESET_POWERON_WDT_E" 2 "SWRESET_POWERON_KL15_E" 3 "SWRESET_HW_E" 4 "SWRESET_WDT_E" 4096 "TRAP_MMU_VAF_E" 4097 "TRAP_MMU_VAP_E" 4098 "TRAP_INTPROT_PRIV_E" 4099 "TRAP_INTPROT_MPR_E" 4100 "TRAP_INTPROT_MPW_E" 4101 "TRAP_INTPROT_MPX_E" 4102 "TRAP_INTPROT_MPP_E" 4103 "TRAP_INTPROT_MPN_E" 4104 "TRAP_INTPROT_GRWP_E" 4105 "TRAP_INSTRERR_IOPC_E" 4106 "TRAP_INSTRERR_UOPC_E" 4107 "TRAP_INSTRERR_OPD_E" 4108 "TRAP_INSTRERR_ALN_E" 4109 "TRAP_INSTRERR_MEM_E" 4110 "TRAP_CONTMANA_FCD_E" 4111 "TRAP_CONTMANA_CDO_E" 4112 "TRAP_CONTMANA_CDU_E" 4113 "TRAP_CONTMANA_FCU_E" 4114 "TRAP_CONTMANA_CSU_E" 4115 "TRAP_CONTMANA_CTYP_E" 4116 "TRAP_CONTMANA_NEST_E" 4117 "TRAP_SYSBUSERR_PSE_E" 4118 "TRAP_SYSBUSERR_DSE_E" 4119 "TRAP_SYSBUSERR_DAE_E" 4120 "TRAP_SYSBUSERR_CAE_E" 4121 "TRAP_SYSBUSERR_PIE_E" 4122 "TRAP_SYSBUSERR_DIE_E" 4123 "TRAP_ASSTRAP_OVF_E" 4124 "TRAP_ASSTRAP_SOVF_E" 4125 "TRAP_SYSCALL_SYS_E" 4126 "TRAP_NMI_ESR0_E" 4127 "TRAP_NMI_ESR1_E" 4128 "TRAP_NMI_RES0_E" 4129 "TRAP_NMI_WDT_E" 4130 "TRAP_NMI_PE_E" 4131 "TRAP_NMI_OSCLWD_E" 4132 "TRAP_NMI_OSCHWD_E" 4133 "TRAP_NMI_OSCSPWD_E" 4134 "TRAP_NMI_SYSVCOLCK_E" 4135 "TRAP_NMI_ERAYVCOLCKT" 4136 "TRAP_NMI_FLOT_E" 4137 "TRAP_PE_P_IED_E" 4138 "TRAP_PE_P_IE_T_E" 4139 "TRAP_PE_P_IE_C_E" 4140 "TRAP_PE_P_IE_S_E" 4141 "TRAP_PE_P_IE_B_E" 4142 "TRAP_PE_D_IED_E" 4143 "TRAP_PE_D_IE_T_E" 4144 "TRAP_PE_D_IE_C_E" 4145 "TRAP_PE_D_IE_S_E" 4146 "TRAP_PE_D_IE_B_E" 4147 "TRAP_NMIPE_LDRAM_DSPR_E" 4148 "TRAP_NMIPE_DTAG_E" 4149 "TRAP_NMIPE_SPRAM_PSPR_E" 4150 "TRAP_NMIPE_PTAG_E" 4151 "TRAP_NMIPE_PMU_LMU_E" 4152 "TRAP_NMIPE_PRAM_E" 4153 "TRAP_NMIPE_CMEM_E" 4154 "TRAP_NMIPE_CAN_E" 4155 "TRAP_NMIPE_ERAY_E" 4156 "TRAP_NMIPE_SRI_E" 4157 "TRAP_NMIPE_EBU_E" 4158 "TRAP_NMIPE_BMU_E" 8192 "SWRESET_POWERON_SIMU_E" 8193 "SWRESET_HRESET_SIMU_E" 8194 "SWRESET_RB_PROG_E" 8195 "SWRESET_SOFTRESET_5VUNDERVOLTAGE_E" 8196 "SWRESET_SOFTRESET_POSTDRV2PREDRV_E" 8197 "SWRESET_CBPROG_E" 8198 "SWRESET_CBCPU_E" 8199 "SWRESET_SBDUMMY_1_E" 8200 "SWRESET_SBDUMMY_2_E" 8201 "SWRESET_SBDUMMY_3_E" 8202 "SWRESET_SBDUMMY_4_E" 8203 "SWRESET_SBDUMMY_5_E" 8204 "SWRESET_SBDUMMY_6_E" 8205 "SWRESET_SBDUMMY_7_E" 8206 "SWRESET_SBDUMMY_8_E" 12288 "RESET_SWRESET_BYP_SHUTDOWN" 12289 "SWRST_CAN_MESSAGECONFIG" 12290 "SWRST_EEPBANDGAP_E" 12291 "SWRST_EEPNODEBUGGER_E" 12292 "SWRST_EEPDELENVRAM_E" 12293 "SWRST_WRITE_ERRORS_SECTORCHANGE_E" 12294 "SWRST_EEPACTFIRSTINIT_E" 12295 "RESET_SWRESET_EPMHCRS_WAIT_PCP_RESET_E" 12296 "RESET_SWRESET_ESC_SCHED_RESET_E" 12297 "SWRST_EXECON_FAULTYSTATE_E" 12298 "RESET_SWRESET_ILLEGAL_OPCODE" 12299 "RESET_SWRESET_ILLEGAL_RETURN_TO_MAIN" 12300 "RESET_SWRESET_MEMLAY_MP_ACCESS" 12301 "RESET_SWRESET_INTERRUPTLOCK_EXPECTED" 12302 "RESET_USERSTACKOVERFLOW_DETECTED" 12303 "SWRST_HWEMONDEFAULT_E" 12304 "RESET_ERRINTR_E" 12305 "RESET_SWRESET_SVBBETAS_SHUTDOWN" 12306 "SWRESET_CALWAKEUP_E" 12307 "SWRESET_DEADLINE1MS_E" 12308 "SWRESET_DEADLINE10MS_E" 12309 "SWRESET_DEADLINEBG_E" 12310 "SWRESET_NMIDISABLED_E" 12311 "SWRESET_POSTDRIVE_E" 12312 "SWRESET_UNEXPSYCSTSUB_E" 12313 "SWRESET_SOFTRESET_WAKEUP_E" 12314 "SWRESET_SOFTRESET_SHUTDOWN_E" 12315 "SWRESET_T15RSTSHUTDOWN_E" 12316 "SWRESET_UNDERVOLTAGE_E" 12317 "RESET_SWRESET_SWOVER_DONE" 12318 "SWRESET_CORE_ENV_E" 12319 "SWRST_ADCI_ERROR_E" 12320 "RESET_DMA_ERROR_E" 12321 "SWRST_FLASHCONFIG_E" 12322 "SWRESET_PCP_ERROR_E" /end COMPU_VTAB
/begin COMPU_METHOD Resist "" RAT_FUNC "%6.3" "Ohm" COEFFS 0 10 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD Rtmo_Percent_u16 "" RAT_FUNC "%6.4" "%" COEFFS 0 65536 0 0 0 100 /end COMPU_METHOD
/begin COMPU_METHOD Rtmo_Time_us "" RAT_FUNC "%6.4" "us" COEFFS 0 90 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD r_q0p15625 "" RAT_FUNC "%6.3" "Ohm" COEFFS 0 65536 0 0 0 10240 /end COMPU_METHOD
/begin COMPU_METHOD r_q3p0518Em5 "" RAT_FUNC "%7.6" "Ohm" COEFFS 0 32768 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD r_uw_q2 "" RAT_FUNC "%6.2" "Ohm" COEFFS 0 1 0 0 0 2 /end COMPU_METHOD
/begin COMPU_METHOD spg_q0p00039 "" RAT_FUNC "%6.5" "V" COEFFS 0 1 0 0 0 0.000390625 /end COMPU_METHOD
/begin COMPU_METHOD spg_q0p00488 "" RAT_FUNC "%6.4" "V" COEFFS 0 1024 0 0 0 5 /end COMPU_METHOD
/begin COMPU_METHOD spg_q0p005 "" RAT_FUNC "%6.4" "V" COEFFS 0 1 0 0 0 0.005 /end COMPU_METHOD
/begin COMPU_METHOD spg_q0p1 "" RAT_FUNC "%6.3" "V" COEFFS 0 1 0 0 0 0.1 /end COMPU_METHOD
/begin COMPU_METHOD spg_q4p88Em4 "" RAT_FUNC "%6.5" "V" COEFFS 0 2048 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD spg_sw_q0p0001 "" RAT_FUNC "%6.5" "V" COEFFS 0 32768 0 0 0 3.3 /end COMPU_METHOD
/begin COMPU_METHOD spg_uw_q0p00488 "" RAT_FUNC "%6.4" "V" COEFFS 0 1024 0 0 0 5 /end COMPU_METHOD
/begin COMPU_METHOD spg_uw_q0p00488_o1 "" RAT_FUNC "%6.3" "V" COEFFS 0 1024 1024 0 0 5 /end COMPU_METHOD
/begin COMPU_METHOD SyC_PostDrv_State "" TAB_VERB "%6.3" "" COMPU_TAB_REF SyC_PostDrv_State /end COMPU_METHOD
/begin COMPU_VTAB SyC_PostDrv_State "" TAB_VERB 9 0 "SYC_POSTDRV_INACTV" 1 "SYC_POSTDRV_DSM_BGN" 2 "SYC_POSTDRV_EEP_BGN" 3 "SYC_POSTDRV_WAIT" 4 "SYC_POSTDRV_NWM" 5 "SYC_POSTDRV_DSM_END" 6 "SYC_POSTDRV_EEP_END" 7 "SYC_POSTDRV_MIN_TIME" 8 "SYC_POSTDRV_DONE" /end COMPU_VTAB
/begin COMPU_METHOD SyC_PreDrv_State "" TAB_VERB "%6.3" "" COMPU_TAB_REF SyC_PreDrv_State /end COMPU_METHOD
/begin COMPU_VTAB SyC_PreDrv_State "" TAB_VERB 10 0 "SYC_PREDRV_INI_DRV" 1 "SYC_PREDRV_DONE" 2 "SYC_PREDRV_INI_SHDWN" 3 "SYC_PREDRV_PROLONG" 4 "SYC_PREDRV_NWM" 5 "SYC_PREDRV_EEP" 6 "SYC_PREDRV_DSM" 7 "SYC_PREDRV_MR" 8 "SYC_PREDRV_MOM" 9 "SYC_PREDRV_EXIT" /end COMPU_VTAB
/begin COMPU_METHOD t100msxs_uw_b6553p6 "" RAT_FUNC "%6.3" "s" COEFFS 0 10 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD t1p0usxms "" RAT_FUNC "%6.5" "ms" COEFFS 0 1000 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD t1sxs_q1 "" RAT_FUNC "%6.2" "s" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD t1sxs_uw_q1 "" RAT_FUNC "%6.2" "s" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD t50msxs_q0p05 "" RAT_FUNC "%6.4" "s" COEFFS 0 1 0 0 0 0.05 /end COMPU_METHOD
/begin COMPU_METHOD Temp_Cels "" RAT_FUNC "%6.1" "deg C" COEFFS 0 10 2731.4 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD Temp_Fahr "" RAT_FUNC "%6.1" "deg F" COEFFS 0 5.55555555555556 2553.62222222222 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD Temp_Kelv "" RAT_FUNC "%6.3" "K" COEFFS 0 10 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD Temp_Kelv_Sec_CtT_Mon "" RAT_FUNC "%7.6" "deg C/s" COEFFS 0 40960 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD temp_q0p0234 "" RAT_FUNC "%6.4" "K" COEFFS 0 256 0 0 0 6 /end COMPU_METHOD
/begin COMPU_METHOD temp_q0p0234_o273 "" RAT_FUNC "%6.1" "Grad C" COEFFS 0 1 273.15 0 0 0.0234375 /end COMPU_METHOD
/begin COMPU_METHOD ThermalCoEff "" RAT_FUNC "%6.3" "W/m/m/k" COEFFS 0 10 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD ThmCnd "" RAT_FUNC "%6.5" "W/m/K" COEFFS 0 1000 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD THMPMP_TYPAVLACTRLIB_SY_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF THMPMP_TYPAVLACTRLIB_SY_Compu /end COMPU_METHOD
/begin COMPU_VTAB THMPMP_TYPAVLACTRLIB_SY_Compu "" TAB_VERB 2 0 "FALSE" 1 "TRUE" /end COMPU_VTAB
/begin COMPU_METHOD Time100HrsEngOn "" RAT_FUNC "%6.2" "[100h]" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD Time100_us "" RAT_FUNC "%6.0" "us" COEFFS 0 0.01 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD TimeDelay_s "" RAT_FUNC "%12.4" "s" COEFFS 0 0 1 0 0.00023283064365387 0 /end COMPU_METHOD
/begin COMPU_METHOD TimeDelay_s_2 "" RAT_FUNC "%9.4" "s" COEFFS 0 0 1 0 0.0596046447753906 0 /end COMPU_METHOD
/begin COMPU_METHOD TimeDelay_s_Lin_16 "" RAT_FUNC "%6.5" "s" COEFFS 0 6553.4 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD TimeDT "" RAT_FUNC "%6.2" "us" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD TimeEngOn "" RAT_FUNC "%6.2" "s" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD TimeEngOnOBD "" RAT_FUNC "%6.2" "min" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD TimeGPTATick "" RAT_FUNC "%6.4" "ns" COEFFS 0 20 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD TimeHrsEngOn "" RAT_FUNC "%6.0" "[100h]" COEFFS 0 0.01 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD TimeRed "" RAT_FUNC "%6.3" "s" COEFFS 0 6.25 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD TimeRed_OvrNght "" RAT_FUNC "%6.2" "s" COEFFS 0 0.390625 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD Time_1s "" RAT_FUNC "%6.2" "s" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD Time_Dt "" RAT_FUNC "%9.8" "s" COEFFS 0 1000000 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD Time_Hr "" RAT_FUNC "%6.3" "h" COEFFS 0 2 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD Time_msec_q10_COMPU "" RAT_FUNC "%6.1" "ms" COEFFS 0 1 0 0 0 10 /end COMPU_METHOD
/begin COMPU_METHOD Time_msec_q1_COMPU "" RAT_FUNC "%6.2" "ms" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD Time_ms_q0p01_COMPU "" RAT_FUNC "%6.4" "ms" COEFFS 0 100 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD Time_ns_to_us "" RAT_FUNC "%6.5" "us" COEFFS 0 1000 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD Time_PwmHigh "" RAT_FUNC "%6.4" "us" COEFFS 0 20 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD Time_s_1 "" RAT_FUNC "%6.5" "" COEFFS 0 1000 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD Time_s_LoRes "" RAT_FUNC "%6.2" "s" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD Time_usec_q1_COMPU "" RAT_FUNC "%6.2" "us" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD Time_WLvlPWM "" RAT_FUNC "%6.4" "ms" COEFFS 0 20 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD TLE6232_SY_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF TLE6232_SY_Compu /end COMPU_METHOD
/begin COMPU_VTAB TLE6232_SY_Compu "" TAB_VERB 3 0 "no TLE6232" 1 "one TLE6232" 2 "two TLE6232" /end COMPU_VTAB
/begin COMPU_METHOD TLE7209_SY_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF TLE7209_SY_Compu /end COMPU_METHOD
/begin COMPU_VTAB TLE7209_SY_Compu "" TAB_VERB 3 0 "no TLE7209" 1 "one TLE7209" 2 "two TLE7209" /end COMPU_VTAB
/begin COMPU_METHOD TLE8209_SY_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF TLE8209_SY_Compu /end COMPU_METHOD
/begin COMPU_VTAB TLE8209_SY_Compu "" TAB_VERB 7 0 "0" 1 "1" 2 "2" 3 "3" 4 "4" 5 "5" 6 "6" /end COMPU_VTAB
/begin COMPU_METHOD TPROT_FINGERPRINT_SY_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF TPROT_FINGERPRINT_SY_Compu /end COMPU_METHOD
/begin COMPU_VTAB TPROT_FINGERPRINT_SY_Compu "" TAB_VERB 2 0 "False" 1 "True" /end COMPU_VTAB
/begin COMPU_METHOD TQRESL_SC_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF TQRESL_SC_Compu /end COMPU_METHOD
/begin COMPU_VTAB TQRESL_SC_Compu "" TAB_VERB 2 0 "Torque resolution of 0.1Nm" 1 "Torque resolution of 0.125Nm" /end COMPU_VTAB
/begin COMPU_METHOD TransR "" RAT_FUNC "%6.4" "-" COEFFS 0 100 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD TRBCHCMPR_TYPAVLACTRLIB_SY_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF TRBCHCMPR_TYPAVLACTRLIB_SY_Compu /end COMPU_METHOD
/begin COMPU_VTAB TRBCHCMPR_TYPAVLACTRLIB_SY_Compu "" TAB_VERB 2 0 "FALSE" 1 "TRUE" /end COMPU_VTAB
/begin COMPU_METHOD TRBCHLP_TYPAVLACTRLIB_SY_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF TRBCHLP_TYPAVLACTRLIB_SY_Compu /end COMPU_METHOD
/begin COMPU_VTAB TRBCHLP_TYPAVLACTRLIB_SY_Compu "" TAB_VERB 2 0 "FALSE" 1 "TRUE" /end COMPU_VTAB
/begin COMPU_METHOD TrbChN_float "" RAT_FUNC "%6.2" "rpm" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD TRBNBYVLV_TYPAVLACTRLIB_SY_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF TRBNBYVLV_TYPAVLACTRLIB_SY_Compu /end COMPU_METHOD
/begin COMPU_VTAB TRBNBYVLV_TYPAVLACTRLIB_SY_Compu "" TAB_VERB 2 0 "FALSE" 1 "TRUE" /end COMPU_VTAB
/begin COMPU_METHOD Trq "" RAT_FUNC "%6.3" "Nm" COEFFS 0 10 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD TrqInrKd "" RAT_FUNC "%8.7" "%/Nm" COEFFS 0 655360 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD TrqInrKd_16 "" RAT_FUNC "%7.6" "%/Nm" COEFFS 0 40960 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD TrqInrKi "" RAT_FUNC "%7.6" "%/(Nm*s)" COEFFS 0 21474.83648 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD TrqInrKi_8 "" RAT_FUNC "%6.5" "%/(Nm*s)" COEFFS 0 2684.35456 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD TrqInrKp "" RAT_FUNC "%8.7" "%/Nm" COEFFS 0 327680 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD TrqInrKp_128 "" RAT_FUNC "%6.5" "%/Nm" COEFFS 0 2560 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD TrqPrp "" RAT_FUNC "%6.2" "Nm" COEFFS 0 0.625 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD TrqPrpHigh "" RAT_FUNC "%6.3" "Nm" COEFFS 0 10 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD TrqToNSqr "" RAT_FUNC "%10.9" "-" COEFFS 0 10000000 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD TRQ_ENGINTV_SY_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF TRQ_ENGINTV_SY_Compu /end COMPU_METHOD
/begin COMPU_VTAB TRQ_ENGINTV_SY_Compu "" TAB_VERB 2 0 "DISABLED" 1 "ENABLED" /end COMPU_VTAB
/begin COMPU_METHOD Trq_PrcHi "" RAT_FUNC "%6.3" "%" COEFFS 0 8 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD TurboN "" RAT_FUNC "%6.1" "rpm" COEFFS 0 0.1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD TVAVSADIA_FRQ "" RAT_FUNC "%6.3" "Hz" COEFFS 0 10 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD TWCCBALUP_SY_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF TWCCBALUP_SY_Compu /end COMPU_METHOD
/begin COMPU_VTAB TWCCBALUP_SY_Compu "" TAB_VERB 2 0 "not included" 1 "included" /end COMPU_VTAB
/begin COMPU_METHOD TWCOR_HIRES_SC_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF TWCOR_HIRES_SC_Compu /end COMPU_METHOD
/begin COMPU_VTAB TWCOR_HIRES_SC_Compu "" TAB_VERB 2 0 "RES_S8" 1 "RES_S16" /end COMPU_VTAB
/begin COMPU_METHOD txms_ub_q0p05 "" RAT_FUNC "%6.4" "ms" COEFFS 0 20 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD t_q0p0001_ms "" RAT_FUNC "%7.6" "ms" COEFFS 0 10000 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD t_q0p0004_ms "" RAT_FUNC "%6.5" "ms" COEFFS 0 10000 0 0 0 4 /end COMPU_METHOD
/begin COMPU_METHOD t_q0p001 "" RAT_FUNC "%6.5" "s" COEFFS 0 1000 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD t_q0p001_ms "" RAT_FUNC "%6.5" "ms" COEFFS 0 1 0 0 0 0.001 /end COMPU_METHOD
/begin COMPU_METHOD t_q0p002 "" RAT_FUNC "%6.4" "s" COEFFS 0 1000 0 0 0 2 /end COMPU_METHOD
/begin COMPU_METHOD t_q0p01 "" RAT_FUNC "%6.4" "s" COEFFS 0 100 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD t_q0p02 "" RAT_FUNC "%6.4" "s" COEFFS 0 100 0 0 0 2 /end COMPU_METHOD
/begin COMPU_METHOD t_q0p1 "" RAT_FUNC "%6.3" "s" COEFFS 0 10 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD t_q0p2 "" RAT_FUNC "%6.3" "s" COEFFS 0 10 0 0 0 2 /end COMPU_METHOD
/begin COMPU_METHOD t_q10_ms "" RAT_FUNC "%6.1" "ms" COEFFS 0 1 0 0 0 10 /end COMPU_METHOD
/begin COMPU_METHOD t_q1p024_ms "" RAT_FUNC "%6.2" "ms" COEFFS 0 1 0 0 0 1.024 /end COMPU_METHOD
/begin COMPU_METHOD t_q8p0_us "" RAT_FUNC "%6.2" "us" COEFFS 0 1 0 0 0 8 /end COMPU_METHOD
/begin COMPU_METHOD UEGO_MEASONEMSEC_SY_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF UEGO_MEASONEMSEC_SY_Compu /end COMPU_METHOD
/begin COMPU_VTAB UEGO_MEASONEMSEC_SY_Compu "" TAB_VERB 2 0 "False" 1 "True" /end COMPU_VTAB
/begin COMPU_METHOD UEGO_SEPUBATTTHDRIDIAG_SC_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF UEGO_SEPUBATTTHDRIDIAG_SC_Compu /end COMPU_METHOD
/begin COMPU_VTAB UEGO_SEPUBATTTHDRIDIAG_SC_Compu "" TAB_VERB 2 0 "False" 1 "True" /end COMPU_VTAB
/begin COMPU_METHOD undefined "" RAT_FUNC "%6.2" "" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD UPMPREFL_TYPAVLACTRLIB_SY_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF UPMPREFL_TYPAVLACTRLIB_SY_Compu /end COMPU_METHOD
/begin COMPU_VTAB UPMPREFL_TYPAVLACTRLIB_SY_Compu "" TAB_VERB 2 0 "FALSE" 1 "TRUE" /end COMPU_VTAB
/begin COMPU_METHOD Vel "" RAT_FUNC "%6.4" "km/h" COEFFS 0 100 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD Velocity "" RAT_FUNC "%6.4" "m/s" COEFFS 0 178.571428571429 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD VelToN "" RAT_FUNC "%8.7" "(km/h)/rpm" COEFFS 0 100000 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD Vel_SI "" RAT_FUNC "%6.4" "m/s" COEFFS 0 360 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD VFG_SC_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF VFG_SC_Compu /end COMPU_METHOD
/begin COMPU_VTAB VFG_SC_Compu "" TAB_VERB 2 0 "False" 1 "True" /end COMPU_VTAB
/begin COMPU_METHOD vfzg_uw_b512 "" RAT_FUNC "%6.4" "km/h" COEFFS 0 65536 0 0 0 512 /end COMPU_METHOD
/begin COMPU_METHOD VlvVel "" RAT_FUNC "%6.3" "%/s" COEFFS 0 8.192 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD Vol "" RAT_FUNC "%6.4" "l" COEFFS 0 100 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD Vol1 "" RAT_FUNC "%9.8" "l" COEFFS 0 3600000 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD volAdd_ml "" RAT_FUNC "%6.3" "ml" COEFFS 0 10 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD volAdd_ml_fine "" RAT_FUNC "%6.5" "ml" COEFFS 0 1000 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD VolEngCap_COMPU "" RAT_FUNC "%9.8" "m^3" COEFFS 0 1000000 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD volFilgLvl_ml "" RAT_FUNC "%6.2" "ml" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD VolFine "" RAT_FUNC "%7.6" "m^3" COEFFS 0 10000 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD Volt "" RAT_FUNC "%6.3" "mV" COEFFS 0 5 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD VoltPres "" RAT_FUNC "%6.3" "mV*hPa" COEFFS 0 10 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD VoltPres_HiRes "" RAT_FUNC "%6.4" "mV*hPa" COEFFS 0 100 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD Volt_FnReso1 "" RAT_FUNC "%6.3" "mV" COEFFS 0 10 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD Volt_FnReso2 "" RAT_FUNC "%6.5" "mV" COEFFS 0 1000 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD Volt_per_Pres "" RAT_FUNC "%6.5" "mV/hPa" COEFFS 0 1000 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD Volt_q0p002_COMPU "" RAT_FUNC "%6.4" "V" COEFFS 0 500 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD Volt_Sq_HiRes "" RAT_FUNC "%6.3" "mV*mV" COEFFS 0 10 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD Vol_NSC "" RAT_FUNC "%7.6" "L" COEFFS 0 10000 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD WaterMsPrHr "" RAT_FUNC "%6.5" "Kg/h" COEFFS 0 1000 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD XCP_SY_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF XCP_SY_Compu /end COMPU_METHOD
/begin COMPU_VTAB XCP_SY_Compu "" TAB_VERB 2 0 "No XCP" 1 "XCP" /end COMPU_VTAB
/begin COMPU_METHOD XDI_SC_Compu "" TAB_VERB "%6.3" "" COMPU_TAB_REF XDI_SC_Compu /end COMPU_METHOD
/begin COMPU_VTAB XDI_SC_Compu "" TAB_VERB 2 0 "False" 1 "True" /end COMPU_VTAB
/begin COMPU_METHOD zk10msxs_uw_b655 "" RAT_FUNC "%6.2" "s" COEFFS 0 0 65536 0 100 0 /end COMPU_METHOD
/begin COMPU_METHOD zk10msxs_uw_b655p36 "" RAT_FUNC "%6.2" "s" COEFFS 0 0 65536 0 100 0 /end COMPU_METHOD
/begin COMPU_METHOD zw_sb_q0p75 "" RAT_FUNC "%6.3" "Grad KW" COEFFS 0 255 0 0 0 191.25 /end COMPU_METHOD
/begin RECORD_LAYOUT KfAxU8AyU8SstxU8SstyU8WS8 NO_AXIS_PTS_X 1 UBYTE NO_AXIS_PTS_Y 2 UBYTE AXIS_PTS_X 3 UBYTE INDEX_INCR DIRECT AXIS_PTS_Y 4 UBYTE INDEX_INCR DIRECT FNC_VALUES 5 SBYTE COLUMN_DIR DIRECT /end RECORD_LAYOUT
/begin RECORD_LAYOUT KfAxUbAyUbSstxUbSstyUbWUb NO_AXIS_PTS_X 1 UBYTE NO_AXIS_PTS_Y 2 UBYTE AXIS_PTS_X 3 UBYTE INDEX_INCR DIRECT AXIS_PTS_Y 4 UBYTE INDEX_INCR DIRECT FNC_VALUES 5 UBYTE COLUMN_DIR DIRECT /end RECORD_LAYOUT
/begin RECORD_LAYOUT KlAxU8SstxU16WU8 NO_AXIS_PTS_X 1 UWORD AXIS_PTS_X 2 UWORD INDEX_INCR DIRECT FNC_VALUES 3 UBYTE COLUMN_DIR DIRECT /end RECORD_LAYOUT
/begin RECORD_LAYOUT KlAxU8SstxU8WU16 NO_AXIS_PTS_X 1 UBYTE AXIS_PTS_X 2 UBYTE INDEX_INCR DIRECT FNC_VALUES 3 UWORD COLUMN_DIR DIRECT /end RECORD_LAYOUT
/begin RECORD_LAYOUT KwbUb FNC_VALUES 1 UBYTE COLUMN_DIR DIRECT /end RECORD_LAYOUT
/begin RECORD_LAYOUT KwWS32 FNC_VALUES 1 SLONG COLUMN_DIR DIRECT /end RECORD_LAYOUT
/begin RECORD_LAYOUT KwWU16 FNC_VALUES 1 UWORD COLUMN_DIR DIRECT /end RECORD_LAYOUT
/begin RECORD_LAYOUT ValA_Wu32 FNC_VALUES 1 ULONG COLUMN_DIR DIRECT /end RECORD_LAYOUT
/* Merged MEASUREMENT blocks */
/begin MEASUREMENT EH_Global.indicator "" UBYTE EH_CONV_BOOLEAN 1 100 0 1 ECU_ADDRESS 0xd00069d3 /end MEASUREMENT
/begin MEASUREMENT Afr_facLambdaReq "" UWORD fac_2048 1 100 0 2 ECU_ADDRESS 0xd00068a0 /end MEASUREMENT
/begin MEASUREMENT Afr_facRatio "" UWORD fac_2048 1 100 1 31.99951171875 ECU_ADDRESS 0xd000689c /end MEASUREMENT
/begin MEASUREMENT Ais_stDiagnosis "" UBYTE Diagnosis_Errors 1 100 0 7 ECU_ADDRESS 0xd00069ce /end MEASUREMENT
/begin MEASUREMENT Amc_AirMassFlow "" UWORD fac_128 1 100 0.0078125 480 ECU_ADDRESS 0xd0006898 /end MEASUREMENT
/begin MEASUREMENT Amf_facRelAir "" UWORD fac_512 1 100 0 2.5 ECU_ADDRESS 0xd000694c /end MEASUREMENT
/begin MEASUREMENT Amf_mAirPerStr "" UWORD fac_65536 1 100 0 0.99998474121093806 ECU_ADDRESS 0xd0006942 /end MEASUREMENT
/begin MEASUREMENT Apv_stDiagnosis "" UBYTE Diagnosis_Errors 1 100 0 7 ECU_ADDRESS 0xd00069c9 /end MEASUREMENT
/begin MEASUREMENT Bvc_uBatt "" UWORD fac_2048 1 100 0 31.99951171875 ECU_ADDRESS 0xd0006938 /end MEASUREMENT
/begin MEASUREMENT Cov_stDiagnosis "" UBYTE Diagnosis_Errors 1 100 0 7 ECU_ADDRESS 0xd00069c5 /end MEASUREMENT
/begin MEASUREMENT Cpc_pChargeFilt "" UWORD fac_1div4 1 100 0 262140 ECU_ADDRESS 0xd0006930 /end MEASUREMENT
/begin MEASUREMENT Ctc_atCool "" UWORD fac_128 1 100 0.0078125 511.9921875 ECU_ADDRESS 0xd000692c /end MEASUREMENT
/begin MEASUREMENT Doh_flgErrorDiagnosis "" UBYTE ident 1 100 -9.9999999999999995e+36 9.9999999999999995e+36 ECU_ADDRESS 0xd00069c0 /end MEASUREMENT
/begin MEASUREMENT Egc_facEgas "" UWORD fac_512 1 100 0 1 ECU_ADDRESS 0xd0006926 /end MEASUREMENT
/begin MEASUREMENT Eih_flgInputError "" UBYTE ident 1 100 -9.9999999999999995e+36 9.9999999999999995e+36 ECU_ADDRESS 0xd00069bc /end MEASUREMENT
/begin MEASUREMENT Eoh_flgOutputError "" UBYTE ident 1 100 -9.9999999999999995e+36 9.9999999999999995e+36 ECU_ADDRESS 0xd00069bb /end MEASUREMENT
/begin MEASUREMENT Epm_rpmEngSpd "" SWORD fac_2 1 100 0 16383.5 ECU_ADDRESS 0xd0006918 /end MEASUREMENT
/begin MEASUREMENT Erh_flgIOErrorAct "" UBYTE ident 1 100 -9.9999999999999995e+36 9.9999999999999995e+36 ECU_ADDRESS 0xd00069ba /end MEASUREMENT
/begin MEASUREMENT Fmc_mFuel "" UWORD fac_65536 1 100 0 0.99998474121093806 ECU_ADDRESS 0xd0006916 /end MEASUREMENT
/begin MEASUREMENT Fps_stDiagnosis "" UBYTE Diagnosis_Errors 1 100 0 7 ECU_ADDRESS 0xd00069b8 /end MEASUREMENT
/begin MEASUREMENT ICC_flgInterCooler "" UBYTE ident 1 100 -9.9999999999999995e+36 9.9999999999999995e+36 ECU_ADDRESS 0xd00069b6 /end MEASUREMENT
/begin MEASUREMENT Iac_degIgn "" SBYTE IGN_4div3 1 100 -72 78 ECU_ADDRESS 0xd00069b5 /end MEASUREMENT
/begin MEASUREMENT Iac_degIgnIdleSpeed "" SBYTE IGN_4div3 1 100 -72 78 ECU_ADDRESS 0xd00069b3 /end MEASUREMENT
/begin MEASUREMENT Iac_degMinAdvBestTq "" SBYTE IGN_4div3 1 100 -96 95.25 ECU_ADDRESS 0xd00069b2 /end MEASUREMENT
/begin MEASUREMENT Iac_flgIgnCutoff "" UBYTE ident 1 100 -9.9999999999999995e+36 9.9999999999999995e+36 ECU_ADDRESS 0xd00069b1 /end MEASUREMENT
/begin MEASUREMENT Icc_degIgn_Arr "" SBYTE IGN_4div3 1 100 -72 78 ARRAY_SIZE 8 ECU_ADDRESS 0xd0006818 /end MEASUREMENT
/begin MEASUREMENT Icc_idxPfiCdrvInterfaceError "" UBYTE CdrvInterfaceError_type_ 1 100 0 6 ECU_ADDRESS 0xd00069af /end MEASUREMENT
/begin MEASUREMENT Ics_stDiagnosis "" UBYTE Diagnosis_Errors 1 100 0 7 ECU_ADDRESS 0xd00069ac /end MEASUREMENT
/begin MEASUREMENT Isc_IdleSpdCtrlIPart "" SWORD fac_1div2 1 100 -65536 65534 ECU_ADDRESS 0xd000690a /end MEASUREMENT
/begin MEASUREMENT Isc_IdleSpdCtrlPPart "" SWORD fac_1div2 1 100 -65536 65534 ECU_ADDRESS 0xd0006908 /end MEASUREMENT
/begin MEASUREMENT Isc_facIdleSpdStab "" UWORD fac_4096 1 100 0 15.999755859375 ECU_ADDRESS 0xd0006904 /end MEASUREMENT
/begin MEASUREMENT Isc_flgFuelCutoff "" UBYTE ident 1 100 -9.9999999999999995e+36 9.9999999999999995e+36 ECU_ADDRESS 0xd00069aa /end MEASUREMENT
/begin MEASUREMENT Isc_flgIdleSpdCtrlActive "" UBYTE ident 1 100 -9.9999999999999995e+36 9.9999999999999995e+36 ECU_ADDRESS 0xd00069a9 /end MEASUREMENT
/begin MEASUREMENT Itc_flgInjCutoff "" UBYTE ident 1 100 -9.9999999999999995e+36 9.9999999999999995e+36 ECU_ADDRESS 0xd00069a8 /end MEASUREMENT
/begin MEASUREMENT Itc_tiBattDelay "" UWORD ident 1 100 0 26214 ECU_ADDRESS 0xd0006902 /end MEASUREMENT
/begin MEASUREMENT Itc_tiInj "" ULONG ident 1 100 0 3300000 ECU_ADDRESS 0xd0006884 /end MEASUREMENT
/begin MEASUREMENT Itc_tiInjOffset "" SWORD ident 1 100 -10000 10000 ECU_ADDRESS 0xd0006900 /end MEASUREMENT
/begin MEASUREMENT Ivc_degInjEnd "" UBYTE fac_1div6 1 100 0 720 ARRAY_SIZE 3 ECU_ADDRESS 0xd0006894 /end MEASUREMENT
/begin MEASUREMENT Ivc_idxDeveCdrvInterfaceError "" UBYTE CdrvInterfaceError_type_ 1 100 0 6 ECU_ADDRESS 0xd00069a6 /end MEASUREMENT
/begin MEASUREMENT Ivc_idxPfiCdrvInterfaceError "" UBYTE CdrvInterfaceError_type_ 1 100 0 6 ECU_ADDRESS 0xd00069a5 /end MEASUREMENT
/begin MEASUREMENT Ivc_tiInjEffCylInd_Arr "" ULONG ident 1 100 0 3300000 ARRAY_SIZE 8 ECU_ADDRESS 0xd00067f8 /end MEASUREMENT
/begin MEASUREMENT Kl50_stKlemme50 "" UBYTE ident 1 100 -9.9999999999999995e+36 9.9999999999999995e+36 ECU_ADDRESS 0xd00069a1 /end MEASUREMENT
/begin MEASUREMENT Lamsoni "" UWORD fac_2048 1 100 0 15.99951171875 ECU_ADDRESS 0xd00068fa /end MEASUREMENT
/begin MEASUREMENT Lcc_facLambdaCorr "" UWORD fac_2048 1 100 0 2 ECU_ADDRESS 0xd00068f8 /end MEASUREMENT
/begin MEASUREMENT Lmc_Cj125Error "" UBYTE ident 1 100 -9.9999999999999995e+36 9.9999999999999995e+36 ECU_ADDRESS 0xd000699f /end MEASUREMENT
/begin MEASUREMENT Lmc_Heater_error_LSU1 "" UBYTE ident 1 100 0 255 ECU_ADDRESS 0xd000699e /end MEASUREMENT
/begin MEASUREMENT Lmc_Heater_error_LSU2 "" UBYTE ident 1 100 0 255 ECU_ADDRESS 0xd000699d /end MEASUREMENT
/begin MEASUREMENT Lmc_LSU1_IAIP_error "" ULONG ident 1 100 0 4294967295 ECU_ADDRESS 0xd0006874 /end MEASUREMENT
/begin MEASUREMENT Lmc_LSU1_UN_error "" ULONG ident 1 100 0 4294967295 ECU_ADDRESS 0xd0006870 /end MEASUREMENT
/begin MEASUREMENT Lmc_LSU1_VM_error "" ULONG ident 1 100 0 4294967295 ECU_ADDRESS 0xd000686c /end MEASUREMENT
/begin MEASUREMENT Lmc_LSU2_IAIP_error "" ULONG ident 1 100 0 4294967295 ECU_ADDRESS 0xd0006868 /end MEASUREMENT
/begin MEASUREMENT Lmc_LSU2_UN_error "" ULONG ident 1 100 0 4294967295 ECU_ADDRESS 0xd0006864 /end MEASUREMENT
/begin MEASUREMENT Lmc_LSU2_VM_error "" ULONG ident 1 100 0 255 ECU_ADDRESS 0xd0006860 /end MEASUREMENT
/begin MEASUREMENT Lmc_facPresCompRich "" UBYTE fac_128 1 100 0 1.9921875 ECU_ADDRESS 0xd0006999 /end MEASUREMENT
/begin MEASUREMENT Mpc_pManiFilt "" UWORD fac_1div4 1 100 0 262140 ECU_ADDRESS 0xd00068e0 /end MEASUREMENT
/begin MEASUREMENT Mrs_stDiagnosis "" UBYTE Diagnosis_Errors 1 100 0 7 ECU_ADDRESS 0xd0006992 /end MEASUREMENT
/begin MEASUREMENT Mtc_atMani "" UWORD fac_128 1 100 0.0078125 511.9921875 ECU_ADDRESS 0xd00068dc /end MEASUREMENT
/begin MEASUREMENT Opm_flgIOErrorMemIn "" UBYTE ident 1 100 -9.9999999999999995e+36 9.9999999999999995e+36 ECU_ADDRESS 0xd0006989 /end MEASUREMENT
/begin MEASUREMENT Opm_flgIOErrorReset "" UBYTE ident 1 100 -9.9999999999999995e+36 9.9999999999999995e+36 ECU_ADDRESS 0xd0006988 /end MEASUREMENT
/begin MEASUREMENT Opm_idxAct "" UBYTE enumOperationMode 1 100 0 2 ECU_ADDRESS 0xd0006984 /end MEASUREMENT
/begin MEASUREMENT Opm_idxMode "" UBYTE enumOperationMode 1 100 0 2 ECU_ADDRESS 0xd0006983 /end MEASUREMENT
/begin MEASUREMENT Opm_stEngControl0 "" UBYTE ident 1 100 -9.9999999999999995e+36 9.9999999999999995e+36 DISPLAY_IDENTIFIER Opm_stEngControl ECU_ADDRESS 0xd0006982 /end MEASUREMENT
/begin MEASUREMENT Output_Digital_Diagnosis_stState "" UBYTE ident 1 100 0 255 ECU_ADDRESS 0xd0006981 /end MEASUREMENT
/begin MEASUREMENT Output_HBridge_Diagnosis_stState "" UBYTE ident 1 100 0 255 ECU_ADDRESS 0xd0006980 /end MEASUREMENT
/begin MEASUREMENT Output_PWM_Diagnosis_stState "" UBYTE ident 1 100 0 255 ECU_ADDRESS 0xd000697f /end MEASUREMENT
/begin MEASUREMENT Stc_CatalyserHeatingTime "" UWORD fac_100 1 100 0 100 ECU_ADDRESS 0xd00068d8 /end MEASUREMENT
/begin MEASUREMENT Stc_facFuelCorr "" UWORD fac_1000 1 100 0 10 ECU_ADDRESS 0xd00068d6 /end MEASUREMENT
/begin MEASUREMENT Stc_flgCatalyserHeating "" UBYTE ident 1 100 -9.9999999999999995e+36 9.9999999999999995e+36 ECU_ADDRESS 0xd000697b /end MEASUREMENT
/begin MEASUREMENT Stc_flgFuelCorrActive "" UBYTE ident 1 100 -9.9999999999999995e+36 9.9999999999999995e+36 ECU_ADDRESS 0xd000697a /end MEASUREMENT
/begin MEASUREMENT Stc_flgStarterActive "" UBYTE ident 1 100 -9.9999999999999995e+36 9.9999999999999995e+36 ECU_ADDRESS 0xd0006979 /end MEASUREMENT
/begin MEASUREMENT Stc_stStarter "" UBYTE ident 1 100 -9.9999999999999995e+36 9.9999999999999995e+36 ECU_ADDRESS 0xd0006978 /end MEASUREMENT
/begin MEASUREMENT Str_stDiagnosis "" UBYTE Diagnosis_Errors 1 100 0 7 ECU_ADDRESS 0xd0006976 /end MEASUREMENT
/begin MEASUREMENT T2t_facThrValveReq "" SWORD fac_512 1 100 -0.12890625 1 ECU_ADDRESS 0xd00068d0 /end MEASUREMENT
/begin MEASUREMENT T2t_facWasteGateRate "" UWORD fac_10000 1 100 0.01 0.98999999999999999 ECU_ADDRESS 0xd00068ca /end MEASUREMENT
/begin MEASUREMENT T2t_pManiReqFast "" UWORD fac_1div4 1 100 0 262140 ECU_ADDRESS 0xd00068c0 /end MEASUREMENT
/begin MEASUREMENT T2t_tiTaThrValveReqCorr "" FLOAT32_IEEE ident 1 100 0.001 9.9999999999999995e+36 ECU_ADDRESS 0xd0006850 /end MEASUREMENT
/begin MEASUREMENT TEST "" UBYTE ident 1 100 0 255 ECU_ADDRESS 0xd0006973 /end MEASUREMENT
/begin MEASUREMENT Tqs_tqReq "" SWORD fac_128 1 100 -256 255.9921875 ECU_ADDRESS 0xd00068b2 /end MEASUREMENT
/begin MEASUREMENT Tvc_stDiagnosis "" UBYTE Diagnosis_Errors 1 100 0 7 ECU_ADDRESS 0xd0006970 /end MEASUREMENT
/begin MEASUREMENT Wcs_stDiagnosis "" UBYTE Diagnosis_Errors 1 100 0 7 ECU_ADDRESS 0xd000696c /end MEASUREMENT
/begin MEASUREMENT Wgc_stDiagnosis "" UBYTE Diagnosis_Errors 1 100 0 7 ECU_ADDRESS 0xd0006969 /end MEASUREMENT
/begin MEASUREMENT buffer "" UBYTE ident 1 100 -9.9999999999999995e+36 9.9999999999999995e+36 ECU_ADDRESS 0xd0006968 /end MEASUREMENT
/begin MEASUREMENT counter "" ULONG ident 1 100 0 4294967295 ECU_ADDRESS 0xd0006848 /end MEASUREMENT
/begin MEASUREMENT counter.CounterEnabled.Isc.FlexECU_M160 "" ULONG ident 1 100 0 4294967295 ECU_ADDRESS 0xd0006844 /end MEASUREMENT
/begin MEASUREMENT counter.CounterEnabled.Stc.FlexECU_M160 "" ULONG ident 1 100 0 4294967295 ECU_ADDRESS 0xd0006840 /end MEASUREMENT
/begin MEASUREMENT dummy_Starter "" UBYTE ident 1 100 -9.9999999999999995e+36 9.9999999999999995e+36 ECU_ADDRESS 0xd00069da /end MEASUREMENT
/begin MEASUREMENT dummy_facAirPumpRate "" UWORD fac_10000 1 100 0.050000000000000003 0.94999999999999996 ECU_ADDRESS 0xd000695e /end MEASUREMENT
/begin MEASUREMENT dummy_facChOverVlvRate "" UWORD fac_10000 1 100 0.050000000000000003 0.94999999999999996 ECU_ADDRESS 0xd000695c /end MEASUREMENT
/begin MEASUREMENT dummy_facThrValveReq "" SWORD fac_512 1 100 -0.12890625 1 ECU_ADDRESS 0xd000695a /end MEASUREMENT
/begin MEASUREMENT dummy_stAirInjReacPump "" UBYTE ident 1 100 -9.9999999999999995e+36 9.9999999999999995e+36 ECU_ADDRESS 0xd00069d9 /end MEASUREMENT
/begin MEASUREMENT dummy_stFuelPump "" UBYTE ident 1 100 -9.9999999999999995e+36 9.9999999999999995e+36 ECU_ADDRESS 0xd00069d8 /end MEASUREMENT
/begin MEASUREMENT dummy_stIntercooler "" UBYTE ident 1 100 -9.9999999999999995e+36 9.9999999999999995e+36 ECU_ADDRESS 0xd00069d7 /end MEASUREMENT
/begin MEASUREMENT dummy_stMainRelais "" UBYTE ident 1 100 -9.9999999999999995e+36 9.9999999999999995e+36 ECU_ADDRESS 0xd00069a2 /end MEASUREMENT
/begin MEASUREMENT memory "" FLOAT32_IEEE ident 1 100 -9.9999999999999995e+36 9.9999999999999995e+36 DISPLAY_IDENTIFIER memory0 ECU_ADDRESS 0xd0006838 /end MEASUREMENT
/begin MEASUREMENT memory1.PID.Lmc.FlexECU_M160 "" SWORD DtyCyc_flex 1 100 -327.68000000000001 327.67000000000002 ECU_ADDRESS 0xd0006956 /end MEASUREMENT
/begin MEASUREMENT memory2.PID.Lmc.FlexECU_M160 "" SWORD DtyCyc_flex 1 100 -327.68000000000001 327.67000000000002 ECU_ADDRESS 0xd0006954 /end MEASUREMENT
/begin MEASUREMENT oldSignal "" UBYTE ident 1 100 -9.9999999999999995e+36 9.9999999999999995e+36 ECU_ADDRESS 0xd00069d6 /end MEASUREMENT
/begin MEASUREMENT status "" UBYTE ident 1 100 -9.9999999999999995e+36 9.9999999999999995e+36 ECU_ADDRESS 0xd00069d5 /end MEASUREMENT
/begin MEASUREMENT status.RSFlipFlop.Stc.FlexECU_M160 "" UBYTE ident 1 100 -9.9999999999999995e+36 9.9999999999999995e+36 ECU_ADDRESS 0xd00069d4 /end MEASUREMENT
/begin MEASUREMENT Iac_deltaDeg "" UWORD fac_1div4 1 100 0 262140 ECU_ADDRESS 0xd0006932 /end MEASUREMENT
/* Merged CHARACTERISTIC blocks */
/begin CHARACTERISTIC EH_Global.enabler "" VALUE 0x802852bc EH_UBYTE 1 EH_CONV_BOOLEAN 0 1 /end CHARACTERISTIC
/begin CHARACTERISTIC EH_HookCount "EHOOKS has hooked 0 variables at 2014.01.16 13:45:39" VALUE 0x8028523e EH_UWORD 65535 EH_CONV_IDENT 0 65535 /end CHARACTERISTIC
/begin CHARACTERISTIC Ais_pinSens_C "" VALUE 0x802852b7 EH_UBYTE 10 DioSet_Pin_t_ 0 10 /end CHARACTERISTIC
/begin CHARACTERISTIC Amc_pinSens_C0 "" VALUE 0x802852b4 EH_UBYTE 29 Adc_Pin_t_ 0 29 DISPLAY_IDENTIFIER Amc_pinSens_C /end CHARACTERISTIC
/begin CHARACTERISTIC Apv_idxLevel_C "" VALUE 0x802852af EH_UBYTE 3 Pwmout_act_t_ 0 3 /end CHARACTERISTIC
/begin CHARACTERISTIC Apv_pinSens_C "" VALUE 0x802852ae EH_UBYTE 21 Pwmout_Pin_t_ 0 21 /end CHARACTERISTIC
/begin CHARACTERISTIC Bvc_pinSens_C "" VALUE 0x802852ad EH_UBYTE 29 Adc_Pin_t_ 0 29 /end CHARACTERISTIC
/begin CHARACTERISTIC Cov_idxLevel_C "" VALUE 0x802852ab EH_UBYTE 3 Pwmout_act_t_ 0 3 /end CHARACTERISTIC
/begin CHARACTERISTIC Cov_pinSens_C "" VALUE 0x802852aa EH_UBYTE 21 Pwmout_Pin_t_ 0 21 /end CHARACTERISTIC
/begin CHARACTERISTIC Cpc_pinsenc_C "" VALUE 0x802852a8 EH_UBYTE 29 Adc_Pin_t_ 0 29 /end CHARACTERISTIC
/begin CHARACTERISTIC Ctc_pinSens_C "" VALUE 0x802852a7 EH_UBYTE 29 Adc_Pin_t_ 0 29 /end CHARACTERISTIC
/begin CHARACTERISTIC Egc_pinSens1_C "" VALUE 0x802852a3 EH_UBYTE 29 Adc_Pin_t_ 0 29 /end CHARACTERISTIC
/begin CHARACTERISTIC Egc_pinSens2_C "" VALUE 0x802852a2 EH_UBYTE 29 Adc_Pin_t_ 0 29 /end CHARACTERISTIC
/begin CHARACTERISTIC Fmc_tiTFuelMassCorr "" VALUE 0x80285174 EH_FLOAT32_IEEE 9.9999999999999995e+36 ident 0.001 9.9999999999999995e+36 /end CHARACTERISTIC
/begin CHARACTERISTIC Fps_pinSens_C "" VALUE 0x8028529d EH_UBYTE 10 DioSet_Pin_t_ 0 10 /end CHARACTERISTIC
/begin CHARACTERISTIC Icc_idxFadeInSource "" VALUE 0x80285295 EH_UBYTE 8 IgnCl_fdoutSources_t_ 0 8 /end CHARACTERISTIC
/begin CHARACTERISTIC Icc_idxFadeOutSource "" VALUE 0x80285294 EH_UBYTE 8 IgnCl_fdoutSources_t_ 0 8 /end CHARACTERISTIC
/begin CHARACTERISTIC Ics_pinSens_C "" VALUE 0x80285291 EH_UBYTE 10 DioSet_Pin_t_ 0 10 /end CHARACTERISTIC
/begin CHARACTERISTIC Kl50_Dioget "" VALUE 0x80285272 EH_UBYTE 9 DioGet_Pin_t_ 0 9 /end CHARACTERISTIC
/begin CHARACTERISTIC Kl50_pinSens_C "" VALUE 0x80285271 EH_UBYTE 9 DioGet_Pin_t_ 0 9 /end CHARACTERISTIC
/begin CHARACTERISTIC Lmc_ADC_pinname "" VALUE 0x8028526e EH_UBYTE 29 Adc_Pin_t_ 0 29 /end CHARACTERISTIC
/begin CHARACTERISTIC Lmc_pinsens_C "" VALUE 0x8028526c EH_UBYTE 3 Lambda_SensorNum_ 0 3 /end CHARACTERISTIC
/begin CHARACTERISTIC Mpc_pinSens_C "" VALUE 0x8028526b EH_UBYTE 29 Adc_Pin_t_ 0 29 /end CHARACTERISTIC
/begin CHARACTERISTIC Mrs_pinSens_C "" VALUE 0x80285269 EH_UBYTE 10 DioSet_Pin_t_ 0 10 /end CHARACTERISTIC
/begin CHARACTERISTIC Mtc_pinSens_C "" VALUE 0x80285267 EH_UBYTE 29 Adc_Pin_t_ 0 29 /end CHARACTERISTIC
/begin CHARACTERISTIC Opc_Inputget "" VALUE 0x80285265 EH_UBYTE 9 DioGet_Pin_t_ 0 9 /end CHARACTERISTIC
/begin CHARACTERISTIC Opc_pinSens_C "" VALUE 0x80285264 EH_UBYTE 9 DioGet_Pin_t_ 0 9 /end CHARACTERISTIC
/begin CHARACTERISTIC Sprungantwort "" VALUE 0x802851b4 EH_SWORD 100 DtyCyc_flex 0 100 /end CHARACTERISTIC
/begin CHARACTERISTIC Str_pinSens_C "" VALUE 0x8028525d EH_UBYTE 10 DioSet_Pin_t_ 0 10 /end CHARACTERISTIC
/begin CHARACTERISTIC Tvc_idxLevel_C "" VALUE 0x80285252 EH_UBYTE 3 Pwmout_act_t_ 0 3 /end CHARACTERISTIC
/begin CHARACTERISTIC Tvc_pinAct_C "" VALUE 0x80285251 EH_UBYTE 2 HBridge_Pin_t_ 0 2 /end CHARACTERISTIC
/begin CHARACTERISTIC Tvc_pinSens1_C "" VALUE 0x80285250 EH_UBYTE 29 Adc_Pin_t_ 0 29 /end CHARACTERISTIC
/begin CHARACTERISTIC Tvc_pinSens2_C "" VALUE 0x8028524f EH_UBYTE 29 Adc_Pin_t_ 0 29 /end CHARACTERISTIC
/begin CHARACTERISTIC Wcs_pinSens_C "" VALUE 0x8028524d EH_UBYTE 10 DioSet_Pin_t_ 0 10 /end CHARACTERISTIC
/begin CHARACTERISTIC Wgc_idxLevel_C "" VALUE 0x8028524a EH_UBYTE 3 Pwmout_act_t_ 0 3 /end CHARACTERISTIC
/begin CHARACTERISTIC Wgc_pinSens_C "" VALUE 0x80285249 EH_UBYTE 21 Pwmout_Pin_t_ 0 21 /end CHARACTERISTIC
/begin CHARACTERISTIC Lcc_EngSpd2facIntegrator_CUR "" CURVE 0x8028585c EH_LAYOUT_Lcc_EngSpd2facIntegrator_CUR 1.9999999999999999e+37 ident -9.9999999999999995e+36 9.9999999999999995e+36
 /begin AXIS_DESCR STD_AXIS Epm_rpmEngSpd fac_2 7 -9.9999999999999995e+36 9.9999999999999995e+36 DEPOSIT ABSOLUTE /end AXIS_DESCR
/end CHARACTERISTIC
/* Merged AXIS_PTS blocks */ /* Merged COMPU_METHOD blocks */
/begin COMPU_METHOD EH_CONV_IDENT "Identity formula" RAT_FUNC "%12.4" "" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD EH_CONV_BOOLEAN "Boolean formula" TAB_VERB "%12.4" "" COMPU_TAB_REF EH_CONV_BOOLEAN_TABLE /end COMPU_METHOD
/begin COMPU_METHOD EH_CONV_ADDSUB "Add/subtract formula" TAB_VERB "%12.4" "" COMPU_TAB_REF EH_CONV_ADDSUB_TABLE /end COMPU_METHOD
/begin COMPU_METHOD Adc_Pin_t_ "" TAB_VERB "%9.6f" "" COMPU_TAB_REF EH_VTAB_Adc_Pin_t_ /end COMPU_METHOD
/begin COMPU_METHOD CdrvInterfaceError_type_ "" TAB_VERB "%9.6f" "" COMPU_TAB_REF EH_VTAB_CdrvInterfaceError_type_ /end COMPU_METHOD
/begin COMPU_METHOD Diagnosis_Errors "" TAB_VERB "%9.6f" "" COMPU_TAB_REF EH_VTAB_Diagnosis_Errors /end COMPU_METHOD
/begin COMPU_METHOD DioGet_Pin_t_ "" TAB_VERB "%9.6f" "" COMPU_TAB_REF EH_VTAB_DioGet_Pin_t_ /end COMPU_METHOD
/begin COMPU_METHOD DioSet_Pin_t_ "" TAB_VERB "%9.6f" "" COMPU_TAB_REF EH_VTAB_DioSet_Pin_t_ /end COMPU_METHOD
/begin COMPU_METHOD DtyCyc_flex "" RAT_FUNC "%9.6f" "" COEFFS 0 100 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD HBridge_Pin_t_ "" TAB_VERB "%9.6f" "" COMPU_TAB_REF EH_VTAB_HBridge_Pin_t_ /end COMPU_METHOD
/begin COMPU_METHOD IGN_4div3 "" RAT_FUNC "%9.6f" "" COEFFS 0 4 0 0 0 3 /end COMPU_METHOD
/begin COMPU_METHOD IgnCl_fdoutSources_t_ "" TAB_VERB "%9.6f" "" COMPU_TAB_REF EH_VTAB_IgnCl_fdoutSources_t_ /end COMPU_METHOD
/begin COMPU_METHOD Lambda_SensorNum_ "" TAB_VERB "%9.6f" "" COMPU_TAB_REF EH_VTAB_Lambda_SensorNum_ /end COMPU_METHOD
/begin COMPU_METHOD Pwmout_Pin_t_ "" TAB_VERB "%9.6f" "" COMPU_TAB_REF EH_VTAB_Pwmout_Pin_t_ /end COMPU_METHOD
/begin COMPU_METHOD Pwmout_act_t_ "" TAB_VERB "%9.6f" "" COMPU_TAB_REF EH_VTAB_Pwmout_act_t_ /end COMPU_METHOD
/begin COMPU_METHOD enumOperationMode "" TAB_VERB "%9.6f" "" COMPU_TAB_REF EH_VTAB_enumOperationMode /end COMPU_METHOD
/begin COMPU_METHOD fac_100 "" RAT_FUNC "%9.6f" "ms" COEFFS 0 100 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD fac_1000 "" RAT_FUNC "%9.6f" "us" COEFFS 0 1000 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD fac_10000 "" RAT_FUNC "%9.6f" "-" COEFFS 0 10000 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD fac_1024 "" RAT_FUNC "%9.6f" "nix" COEFFS 0 1024 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD fac_128 "" RAT_FUNC "%9.6f" "Grad" COEFFS 0 128 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD fac_1div2 "" RAT_FUNC "%9.6f" "mV" COEFFS 0 0.5 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD fac_1div4 "" RAT_FUNC "%9.6f" "V" COEFFS 0 0.25 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD fac_1div6 "" RAT_FUNC "%9.6f" "g/mol" COEFFS 0 1 0 0 0 6 /end COMPU_METHOD
/begin COMPU_METHOD fac_2 "" RAT_FUNC "%9.6f" "U/min" COEFFS 0 2 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD fac_2048 "" RAT_FUNC "%9.6f" "g/km" COEFFS 0 2048 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD fac_4096 "" RAT_FUNC "%9.6f" "m/K" COEFFS 0 4096 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD fac_512 "" RAT_FUNC "%9.6f" "rpm" COEFFS 0 512 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD fac_65536 "" RAT_FUNC "%9.6f" "m/K/s" COEFFS 0 65536 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD ident "" RAT_FUNC "%9.6f" "grad" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD sm_OpMode_enum "" TAB_VERB "%9.6f" "" COMPU_TAB_REF EH_VTAB_sm_OpMode_enum /end COMPU_METHOD
/* Merged COMPU_VTAB blocks */
/begin COMPU_VTAB EH_CONV_BOOLEAN_TABLE "" TAB_VERB 2 0 "FALSE" 1 "TRUE" /end COMPU_VTAB
/begin COMPU_VTAB EH_CONV_ADDSUB_TABLE "" TAB_VERB 2 0 "ADD" 1 "SUBTRACT" /end COMPU_VTAB
/begin COMPU_VTAB EH_VTAB_Adc_Pin_t_ "" TAB_VERB 30 0 "I_A_AN01_" 1 "I_A_AN02_" 2 "I_A_AN03_" 3 "I_A_AN05_" 4 "I_A_AN06_" 5 "I_A_AN07_" 6 "I_A_AN08_" 7 "I_A_AN10_" 8 "I_A_AN11_" 9 "I_A_AN12_" 10 "I_A_AN13_" 11 "I_A_AN14_" 12 "I_A_AN15_" 13 "I_A_AN16_" 14 "I_A_AN18_" 15 "I_A_AN19_" 16 "I_A_AN20_" 17 "I_A_AN21_" 18 "I_A_AN23_" 19 "I_A_AN32_" 20 "I_A_AN35_" 21 "I_A_AN36_" 22 "I_A_AN37_" 23 "I_A_AN39_" 24 "I_A_AN100_" 25 "I_A_AN101_" 26 "I_A_AN103_" 27 "I_A_AN104_" 28 "I_A_AN105_" 29 "I_A_AN106_" /end COMPU_VTAB
/begin COMPU_VTAB EH_VTAB_CdrvInterfaceError_type_ "" TAB_VERB 7 0 "CDRV_E_OK_" 1 "CDRV_E_NULL_PTR_" 2 "CDRV_E_PFI_" 3 "CDRV_E_GDI_" 4 "CDRV_E_S0_" 5 "CDRV_E_S1_" 6 "CDRV_E_CYL_NO_" /end COMPU_VTAB
/begin COMPU_VTAB EH_VTAB_Diagnosis_Errors "" TAB_VERB 8 0 "OK" 1 "OverTemp" 2 "OpenCircuit" 3 "ShortToBatt" 4 "ShortToBattNEG" 5 "ShortToGnd" 6 "ShortToGndPOS" 7 "ShortToGndNEG" /end COMPU_VTAB
/begin COMPU_VTAB EH_VTAB_DioGet_Pin_t_ "" TAB_VERB 10 0 "I_S_T15_" 1 "I_S_DIG02_" 2 "I_S_DIG05_" 3 "I_S_DIG13_" 4 "I_S_DIG14_" 5 "I_S_DIG15_" 6 "I_S_DIG16_" 7 "I_S_DIG17_" 8 "I_S_DIG20_" 9 "I_S_DIG50_" /end COMPU_VTAB
/begin COMPU_VTAB EH_VTAB_DioSet_Pin_t_ "" TAB_VERB 11 0 "O_S_MRLY_" 1 "O_S_RL09_" 2 "O_S_RL14_" 3 "O_S_RL29_" 4 "O_S_RL30_" 5 "O_S_RL31_" 6 "O_S_RL33_" 7 "O_S_RL34_" 8 "O_S_RL35_" 9 "O_S_RL41_" 10 "O_S_RL43_" /end COMPU_VTAB
/begin COMPU_VTAB EH_VTAB_HBridge_Pin_t_ "" TAB_VERB 3 0 "O_T_DC1_" 1 "O_T_DC2_" 2 "O_T_DC3_" /end COMPU_VTAB
/begin COMPU_VTAB EH_VTAB_IgnCl_fdoutSources_t_ "" TAB_VERB 9 0 "CDRV_IGN_FDOUT_DMDZAG_" 1 "CDRV_IGN_FDOUT_AIRBAG_" 2 "CDRV_IGN_FDOUT_WDA_" 3 "CDRV_IGN_FDOUT_RDE_" 4 "CDRV_IGN_FDOUT_NLPH_" 5 "CDRV_IGN_FDOUT_CYLCUTOFF_" 6 "CDRV_IGN_FDOUT_BACKUP_CAS_" 7 "CDRV_IGN_FDOUT_ENGSTALL_" 8 "CDRV_IGN_FDOUT_CUSTOM0_" /end COMPU_VTAB
/begin COMPU_VTAB EH_VTAB_Lambda_SensorNum_ "" TAB_VERB 4 0 "LSU1_" 1 "LSU2_" 2 "LSF1_" 3 "LSF2_" /end COMPU_VTAB
/begin COMPU_VTAB EH_VTAB_Pwmout_Pin_t_ "" TAB_VERB 22 0 "O_T_RL10_" 1 "O_T_RL13_" 2 "O_T_RL19_" 3 "O_T_RL20_" 4 "O_T_RL22_" 5 "O_T_RL23_" 6 "O_T_RL25_" 7 "O_T_RL26_" 8 "O_T_RL27_" 9 "O_T_RL28_" 10 "O_T_RL38_" 11 "O_T_RL39_" 12 "O_T_RL40_" 13 "O_T_RL42_" 14 "O_T_RL44_" 15 "O_T_RL45_" 16 "O_T_RL46_" 17 "O_T_RL47_" 18 "O_T_RL48_" 19 "O_T_RL49_" 20 "O_T_RL50_" 21 "O_T_RH02_" /end COMPU_VTAB
/begin COMPU_VTAB EH_VTAB_Pwmout_act_t_ "" TAB_VERB 4 0 "Lo_" 1 "Hi_" 2 "PWMOUT_NINV_E_" 3 "PWMOUT_INV_E_" /end COMPU_VTAB
/begin COMPU_VTAB EH_VTAB_enumOperationMode "" TAB_VERB 3 0 "Off" 1 "Normal" 2 "IOError" /end COMPU_VTAB
/begin COMPU_VTAB EH_VTAB_sm_OpMode_enum "" TAB_VERB 3 0 "Off_state" 1 "IOError_state" 2 "Normal_state" /end COMPU_VTAB
/* Merged RECORD_LAYOUT blocks */
/begin RECORD_LAYOUT EH_UBYTE FNC_VALUES 1 UBYTE COLUMN_DIR DIRECT /end RECORD_LAYOUT
/begin RECORD_LAYOUT EH_UWORD FNC_VALUES 1 UWORD COLUMN_DIR DIRECT /end RECORD_LAYOUT
/begin RECORD_LAYOUT EH_SWORD FNC_VALUES 1 SWORD COLUMN_DIR DIRECT /end RECORD_LAYOUT
/begin RECORD_LAYOUT EH_SLONG FNC_VALUES 1 SLONG COLUMN_DIR DIRECT /end RECORD_LAYOUT
/begin RECORD_LAYOUT EH_FLOAT32_IEEE FNC_VALUES 1 FLOAT32_IEEE COLUMN_DIR DIRECT /end RECORD_LAYOUT
/begin RECORD_LAYOUT EH_FLOAT64_IEEE FNC_VALUES 1 FLOAT64_IEEE COLUMN_DIR DIRECT /end RECORD_LAYOUT
/begin RECORD_LAYOUT EH_LAYOUT_Lcc_EngSpd2facIntegrator_CUR NO_AXIS_PTS_X 1 UWORD AXIS_PTS_X 2 FLOAT32_IEEE INDEX_INCR DIRECT FNC_VALUES 3 FLOAT32_IEEE COLUMN_DIR DIRECT /end RECORD_LAYOUT
/begin RECORD_LAYOUT EH_LAYOUT_Stc_facFuelCorr_CUR NO_AXIS_PTS_X 1 UWORD AXIS_PTS_X 2 ULONG INDEX_INCR DIRECT FNC_VALUES 3 UWORD COLUMN_DIR DIRECT /end RECORD_LAYOUT
/* Merged GROUP blocks */ /* Begin: Example for Compu Method Referencing to VTAB Range */
/begin MEASUREMENT measurement_with_compu_vtab_range "Example for measurement variable with compu method referencing to a vtab range" UBYTE compu_vtab_range_example 1 0 0 5 ECU_ADDRESS 0x700019E1 /end MEASUREMENT
/begin COMPU_METHOD compu_vtab_range_example "" TAB_VERB "%.0" "-" COMPU_TAB_REF compu_vtab_range_example REF_UNIT SymphonyAutosarUnits_NoUnit /end COMPU_METHOD
/begin COMPU_VTAB_RANGE compu_vtab_range_example "" 5 0 0 "disabled" 1 1 "detection" 2 2 "lower_range_window" 3 3 "upper_range_window" 4 5 "standby" /end COMPU_VTAB_RANGE
/* End: Example for Compu Method Referencing to VTAB Range */ /* Begin: Example for Compu Method Referencing to table */
/begin CHARACTERISTIC characteristic_with_compu_tab "Example for a characteristic with a compu method referencing to a table" VALUE 0x80991BFA KwWU16 2.550000 computab_mapping_example 0.00 2.550000 FORMAT "%8.6" /end CHARACTERISTIC
/begin COMPU_METHOD computab_mapping_example "" TAB_INTP "%6.3" "s" COMPU_TAB_REF computab_mapping_example /end COMPU_METHOD
/begin COMPU_TAB computab_mapping_example "" TAB_INTP 35 128 2.55 145 2.25 163 2 186 1.75 217 1.5 251 1.3 283 1.15 326 1 362 0.9 407 0.8 465 0.7 541 0.6 649 0.5 720 0.45 809 0.4 923 0.35 1074 0.3 1285 0.25 1524 0.21 1872 0.17 2259 0.14 2426 0.13 2620 0.12 2847 0.11 3118 0.1 3446 0.09 3850 0.08 4362 0.07 5030 0.06 5939 0.05 7248 0.04 9288 0.03 12893 0.02 20713 0.01 32767 0 /end COMPU_TAB
/end MODULE
/end PROJECT
