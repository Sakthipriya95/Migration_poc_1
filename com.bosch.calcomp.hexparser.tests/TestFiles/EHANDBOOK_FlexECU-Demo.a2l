/* Erstellt von DAMOS++ V5.2.0 WinVista */
ASAP2_VERSION 1 4
/begin PROJECT MED1734_Flx_G1 "MEDC17_Core"
/begin HEADER "" VERSION "MED1734_Flx_01" PROJECT_NO MED1734_Flx_G1 /end HEADER
/begin MODULE DIM ""
/begin MOD_PAR "MEDC17_Core" VERSION "MED1734_Flx_01" CUSTOMER_NO "0" USER "" PHONE_NO "" ECU "MED1734N" CPU_TYPE "TriCore"
 /begin MEMORY_SEGMENT Pst80000000 "" RESERVED FLASH INTERN 0x80000000 0xFC78 -1 -1 -1 -1 -1 /begin IF_DATA ASAP1B_KWP2000 ADDRESS_MAPPING 0x80000000 0x0 0xFC78 /end IF_DATA /end MEMORY_SEGMENT
 /begin MEMORY_SEGMENT Pst8000FC78 "" RESERVED FLASH INTERN 0x8000FC78 0x8C -1 -1 -1 -1 -1 /begin IF_DATA ASAP1B_KWP2000 ADDRESS_MAPPING 0x8000FC78 0xFC78 0x8C /end IF_DATA /end MEMORY_SEGMENT
 /begin MEMORY_SEGMENT Pst80020000 "" CODE FLASH INTERN 0x80020000 0x25FF74 -1 -1 -1 -1 -1 /begin IF_DATA ASAP1B_KWP2000 ADDRESS_MAPPING 0x80020000 0x20000 0x25FF74 /end IF_DATA /end MEMORY_SEGMENT
 /begin MEMORY_SEGMENT Pst8027FF74 "" RESERVED FLASH INTERN 0x8027FF74 0x8C -1 -1 -1 -1 -1 /begin IF_DATA ASAP1B_KWP2000 ADDRESS_MAPPING 0x8027FF74 0x27FF74 0x8C /end IF_DATA /end MEMORY_SEGMENT
 /begin MEMORY_SEGMENT Pst802EFC74 "" RESERVED FLASH INTERN 0x802EFC74 0x8C -1 -1 -1 -1 -1 /begin IF_DATA ASAP1B_KWP2000 ADDRESS_MAPPING 0x802EFC74 0x2EFC74 0x8C /end IF_DATA /end MEMORY_SEGMENT
 /begin MEMORY_SEGMENT Pst802EFD00 "" RESERVED FLASH INTERN 0x802EFD00 0x300 -1 -1 -1 -1 -1 /begin IF_DATA ASAP1B_KWP2000 ADDRESS_MAPPING 0x802EFD00 0x2EFD00 0x300 /end IF_DATA /end MEMORY_SEGMENT
 /begin MEMORY_SEGMENT Pst80014000 "" RESERVED FLASH INTERN 0x80014000 0x3E74 -1 -1 -1 -1 -1 /begin IF_DATA ASAP1B_KWP2000 ADDRESS_MAPPING 0x80014000 0x14000 0x3E74 /end IF_DATA /end MEMORY_SEGMENT
 /begin MEMORY_SEGMENT Pst80017E74 "" RESERVED FLASH INTERN 0x80017E74 0x18C -1 -1 -1 -1 -1 /begin IF_DATA ASAP1B_KWP2000 ADDRESS_MAPPING 0x80017E74 0x17E74 0x18C /end IF_DATA /end MEMORY_SEGMENT
 /begin MEMORY_SEGMENT Pst80018000 "" RESERVED FLASH INTERN 0x80018000 0x7E74 -1 -1 -1 -1 -1 /begin IF_DATA ASAP1B_KWP2000 ADDRESS_MAPPING 0x80018000 0x18000 0x7E74 /end IF_DATA /end MEMORY_SEGMENT
 /begin MEMORY_SEGMENT Pst8001FE74 "" RESERVED FLASH INTERN 0x8001FE74 0x18C -1 -1 -1 -1 -1 /begin IF_DATA ASAP1B_KWP2000 ADDRESS_MAPPING 0x8001FE74 0x1FE74 0x18C /end IF_DATA /end MEMORY_SEGMENT
 /begin MEMORY_SEGMENT Pst8000FD04 "" RESERVED FLASH INTERN 0x8000FD04 0x2FC -1 -1 -1 -1 -1 /begin IF_DATA ASAP1B_KWP2000 ADDRESS_MAPPING 0x8000FD04 0xFD04 0x2FC /end IF_DATA /end MEMORY_SEGMENT
 /begin MEMORY_SEGMENT Dst80280000 "" DATA FLASH INTERN 0x80280000 0x6FC74 -1 -1 -1 -1 -1 /begin IF_DATA ETK ADDRESS_MAPPING 0x80280000 0x80800000 0x6FC74 /end IF_DATA /begin IF_DATA ASAP1B_KWP2000 ADDRESS_MAPPING 0x80280000 0x280000 0x6FC74 /end IF_DATA /end MEMORY_SEGMENT
 /begin MEMORY_SEGMENT Ram8086FC80 "" VARIABLES RAM EXTERN 0x8086FC80 0x10380 -1 -1 -1 -1 -1 /begin IF_DATA ASAP1B_KWP2000 ADDRESS_MAPPING 0x8086FC80 0x66FC80 0x10380 /end IF_DATA /end MEMORY_SEGMENT
 /begin MEMORY_SEGMENT RamAFE70000 "" VARIABLES RAM INTERN 0xAFE70000 0x8000 -1 -1 -1 -1 -1 /begin IF_DATA ASAP1B_KWP2000 ADDRESS_MAPPING 0xAFE70000 0x4A0000 0x8000 /end IF_DATA /end MEMORY_SEGMENT
 /begin MEMORY_SEGMENT RamAFE80000 "" VARIABLES RAM INTERN 0xAFE80000 0x2000 -1 -1 -1 -1 -1 /begin IF_DATA ASAP1B_KWP2000 ADDRESS_MAPPING 0xAFE80000 0x4B0000 0x2000 /end IF_DATA /end MEMORY_SEGMENT
 /begin MEMORY_SEGMENT RamC0000000 "" VARIABLES RAM INTERN 0xC0000000 0x8000 -1 -1 -1 -1 -1 /begin IF_DATA ASAP1B_KWP2000 ADDRESS_MAPPING 0xC0000000 0x4C0000 0x8000 /end IF_DATA /end MEMORY_SEGMENT
 /begin MEMORY_SEGMENT RamD0000000 "" VARIABLES RAM INTERN 0xD0000000 0x20000 -1 -1 -1 -1 -1 /begin IF_DATA ASAP1B_KWP2000 ADDRESS_MAPPING 0xD0000000 0x500000 0x20000 /end IF_DATA /end MEMORY_SEGMENT
 /begin MEMORY_SEGMENT RamF0050000 "" VARIABLES RAM INTERN 0xF0050000 0x2000 -1 -1 -1 -1 -1 /begin IF_DATA ASAP1B_KWP2000 ADDRESS_MAPPING 0xF0050000 0x550000 0x2000 /end IF_DATA /end MEMORY_SEGMENT
 /begin MEMORY_SEGMENT RamF0060000 "" VARIABLES RAM INTERN 0xF0060000 0x4000 -1 -1 -1 -1 -1 /begin IF_DATA ASAP1B_KWP2000 ADDRESS_MAPPING 0xF0060000 0x560000 0x4000 /end IF_DATA /end MEMORY_SEGMENT
 /begin CALIBRATION_METHOD /* name calibration methode */ "DataSetId" /* version calibration metode */ 256 /begin CALIBRATION_HANDLE /* adr data set id characteristic */ 0x802B94B2 /end CALIBRATION_HANDLE /end CALIBRATION_METHOD
 SYSTEM_CONSTANT "ADDHTR_CONST" "360"
 SYSTEM_CONSTANT "EXTERNAL HEXFILE POST TREATMENT NAME" "hpt_hexmod17_v363.dll"
 SYSTEM_CONSTANT "EXTERNAL HEXFILE POST TREATMENT PARAMETER" "BLK_START=0x80018000"
 SYSTEM_CONSTANT "AIRMSPRTIMEQ0P0003_RES" "0.0003"
 SYSTEM_CONSTANT "AIRMSPRTIMEQ0P0003_RES_REV" "3333.33333333333"
 SYSTEM_CONSTANT "AIRMSQ0P1_RES" "0.1"
 SYSTEM_CONSTANT "AIRMSQ0P1_RES_REV" "10"
 SYSTEM_CONSTANT "AIRSYS_AREAEFFONE" "1"
 SYSTEM_CONSTANT "AIRSYS_AREAEFFONE_SY" "1"
 SYSTEM_CONSTANT "AIRSYS_MINDEADTIME_SY" "1"
 SYSTEM_CONSTANT "AIRSYS_TEMPTHRPST" "300"
 SYSTEM_CONSTANT "AIRSYS_TEMPTHRPST_SY" "300"
 SYSTEM_CONSTANT "ALTCRNT_LIM_RES" "0.25"
 SYSTEM_CONSTANT "ALTCRNT_OUT_RES" "0.125"
 SYSTEM_CONSTANT "ALTLD_RES" "3.125"
 SYSTEM_CONSTANT "ALTVLTG_OFS" "10.6"
 SYSTEM_CONSTANT "ALTVLTG_RES_SY" "0.1"
 SYSTEM_CONSTANT "ALT_CHPTEMP_OFS" "-32"
 SYSTEM_CONSTANT "ALT_CHPTEMP_RES" "8"
 SYSTEM_CONSTANT "AMPC_RES_REV" "10"
 SYSTEM_CONSTANT "AMPT_NOXLDUNLD_RES" "0.0001"
 SYSTEM_CONSTANT "AMPT_NOXLDUNLD_RES_REV" "10000"
 SYSTEM_CONSTANT "AMPT_NOXRGN_MIN" "0"
 SYSTEM_CONSTANT "AMPT_NOXRGN_RES" "0.0005"
 SYSTEM_CONSTANT "AMPT_NOXRGN_RES_REV" "2000"
 SYSTEM_CONSTANT "AMPT_NOX_RES" "1e-005"
 SYSTEM_CONSTANT "AMPT_NOX_RES_REV" "100000"
 SYSTEM_CONSTANT "AMPT_RES_2" "3.2e-005"
 SYSTEM_CONSTANT "AMPT_RES_2_REV" "31250"
 SYSTEM_CONSTANT "AMPT_SOX1_MIN" "0"
 SYSTEM_CONSTANT "AMPT_SOX1_RES" "0.003"
 SYSTEM_CONSTANT "AMPT_SOX1_RES_FL" "0.003"
 SYSTEM_CONSTANT "ARCOM_SY" "0"
 SYSTEM_CONSTANT "ASMODPRC_PERSEC_RES_REV" "1.6384"
 SYSTEM_CONSTANT "ASMOD_FACAMCOR_RES" "122.0703125"
 SYSTEM_CONSTANT "ASMOD_FACRSTOICH" "14.5"
 SYSTEM_CONSTANT "ASMOD_HENG_RES" "34.8"
 SYSTEM_CONSTANT "ASMOD_HTFLW_RES" "2"
 SYSTEM_CONSTANT "ASMOD_NUMEOMCOEMI_SY" "3"
 SYSTEM_CONSTANT "ASMOD_PHC" "3"
 SYSTEM_CONSTANT "ASMOD_QLMBD" "100"
 SYSTEM_CONSTANT "ASMOD_RGN" "4"
 SYSTEM_CONSTANT "ASMOD_RM" "2"
 SYSTEM_CONSTANT "BBSTVE_SY" "0"
 SYSTEM_CONSTANT "BSP742_SY" "1"
 SYSTEM_CONSTANT "BUSDIAG_BUSOFF_CANMAXNODES" "4"
 SYSTEM_CONSTANT "BYPASS_SY" "1"
 SYSTEM_CONSTANT "CABVLV_TYPAVLACTRLIB_SY" "0"
 SYSTEM_CONSTANT "CALORIFIC_VALUE" "42.5"
 SYSTEM_CONSTANT "CALORY_RES_REV" "1"
 SYSTEM_CONSTANT "CALWUP_SY" "1"
 SYSTEM_CONSTANT "CAMLIFT_RES_REV" "256"
 SYSTEM_CONSTANT "CAMPAR_A_RES_REV" "1024"
 SYSTEM_CONSTANT "CAMSLP_RES_REV" "1024"
 SYSTEM_CONSTANT "CAN_MONITORING_ENBLD_SY" "0"
 SYSTEM_CONSTANT "CAN_MULTIPLEXSORT_ENBLD_SY" "0"
 SYSTEM_CONSTANT "CASI1_SSP_SY" "1"
 SYSTEM_CONSTANT "CASI2_SSP_SY" "1"
 SYSTEM_CONSTANT "CASO1_SSP_SY" "1"
 SYSTEM_CONSTANT "CASO2_SSP_SY" "1"
 SYSTEM_CONSTANT "CASTYP_SY" "0"
 SYSTEM_CONSTANT "CAS_ADAP_SY" "1"
 SYSTEM_CONSTANT "CAS_ANGLE_SY" "1"
 SYSTEM_CONSTANT "CAS_BACKUPVAR_SY" "0"
 SYSTEM_CONSTANT "CAS_BACKUP_SY" "3"
 SYSTEM_CONSTANT "CAS_DELAY_SC" "0"
 SYSTEM_CONSTANT "CAS_DIAG_SY" "2"
 SYSTEM_CONSTANT "CAS_I1_SY" "1"
 SYSTEM_CONSTANT "CAS_I2_SY" "1"
 SYSTEM_CONSTANT "CAS_MAX" "2"
 SYSTEM_CONSTANT "CAS_O1_SY" "1"
 SYSTEM_CONSTANT "CAS_O2_SY" "1"
 SYSTEM_CONSTANT "CAS_OUT_SY" "0"
 SYSTEM_CONSTANT "CAS_SEGCOR_SY" "0"
 SYSTEM_CONSTANT "CIC751_SY" "1"
 SYSTEM_CONSTANT "CJ930_NUMCHP_SY" "0"
 SYSTEM_CONSTANT "CJ930_SY" "0"
 SYSTEM_CONSTANT "CJ945_SY" "0"
 SYSTEM_CONSTANT "CJ950_SY" "0"
 SYSTEM_CONSTANT "CMBTYP_SY" "1"
 SYSTEM_CONSTANT "CNVTCOEFFCATAIR_RES_REV" "50"
 SYSTEM_CONSTANT "CNV_QNT2ANGLE" "219.726562500054"
 SYSTEM_CONSTANT "COEOM_INJCRVMI1NUMSWTMAX_SY" "2"
 SYSTEM_CONSTANT "COESS_RCPTMNG_SY" "0"
 SYSTEM_CONSTANT "COMCIL_LIB_MAX_MSGGRPS" "14"
 SYSTEM_CONSTANT "COMCIL_SAEJ1939Disc_ERR" "2"
 SYSTEM_CONSTANT "COMCIL_SAEJ1939Disc_NA" "3"
 SYSTEM_CONSTANT "COMCIL_SAEJ1939ERR_BP" "1"
 SYSTEM_CONSTANT "COMCIL_SAEJ1939NA_BP" "2"
 SYSTEM_CONSTANT "COMCIL_SAEJ1939RNG_BP" "0"
 SYSTEM_CONSTANT "COMCIL_SAEJ1939_ASCII_ERR" "0"
 SYSTEM_CONSTANT "COMCIL_SAEJ1939_ERR" "254"
 SYSTEM_CONSTANT "COMCIL_SAEJ1939_NA" "255"
 SYSTEM_CONSTANT "COMCIL_SAEJ1939_RNG" "250"
 SYSTEM_CONSTANT "COMPACCPED_ON" "1"
 SYSTEM_CONSTANT "COMPACCPED_SY" "0"
 SYSTEM_CONSTANT "COM_STCANVERMSK_V4" "2383"
 SYSTEM_CONSTANT "COM_STCANVERMSK_V6" "1552"
 SYSTEM_CONSTANT "CONV_KG2L" "785.964912280702"
 SYSTEM_CONSTANT "CONV_MGS2KGS" "1000000"
 SYSTEM_CONSTANT "CRSSENSTYP_SY" "1"
 SYSTEM_CONSTANT "CRSTYP_SY" "0"
 SYSTEM_CONSTANT "CRS_ALTPIN_SY" "0"
 SYSTEM_CONSTANT "CRS_ANGLECOR_SY" "0"
 SYSTEM_CONSTANT "CRS_BACKUP_CASTYP_SY" "2"
 SYSTEM_CONSTANT "CRS_BACKUP_DYN_SY" "0"
 SYSTEM_CONSTANT "CRS_BACKUP_SY" "0"
 SYSTEM_CONSTANT "CRS_CY30CONF_SY" "0"
 SYSTEM_CONSTANT "CRS_DIAG_DETAIL_SY" "0"
 SYSTEM_CONSTANT "CRS_DIAG_SYNCINJLOST_SY" "0"
 SYSTEM_CONSTANT "CRS_MIAP_SY" "0"
 SYSTEM_CONSTANT "CRS_SSP_SY" "1"
 SYSTEM_CONSTANT "CRS_TAA_SY" "0"
 SYSTEM_CONSTANT "CRS_TOOTHAVRG_SY" "1"
 SYSTEM_CONSTANT "CURR_RES" "1"
 SYSTEM_CONSTANT "CURR_RMP_RES_SY" "6553.6"
 SYSTEM_CONSTANT "CVOCFG_SC" "0"
 SYSTEM_CONSTANT "CY100_SY" "0"
 SYSTEM_CONSTANT "CY141_SY" "0"
 SYSTEM_CONSTANT "CY146_SY" "0"
 SYSTEM_CONSTANT "CY320_SY" "1"
 SYSTEM_CONSTANT "CY327_SY" "0"
 SYSTEM_CONSTANT "CYL_MAX" "4"
 SYSTEM_CONSTANT "DCS_OVRDS_ENGPRT" "1"
 SYSTEM_CONSTANT "DDVOL_RES" "10"
 SYSTEM_CONSTANT "DEDIA_VRNTCONF_SY" "0"
 SYSTEM_CONSTANT "DENSFINE_RES_REV" "500"
 SYSTEM_CONSTANT "DEVLIB_4WINDIACMPNENA_SY" "0"
 SYSTEM_CONSTANT "DEVLIB_ACTRPRTCMPNENA_SY" "0"
 SYSTEM_CONSTANT "DEVLIB_ACTRPRTGLWCTLCHK_SY" "0"
 SYSTEM_CONSTANT "DEVLIB_DBG_SY" "1"
 SYSTEM_CONSTANT "DEVLIB_DIACTLLINECMPNENA_SY" "0"
 SYSTEM_CONSTANT "DEVLIB_HBRGADVHWSEL_SY" "0"
 SYSTEM_CONSTANT "DEVLIB_HBRGENA_SY" "0"
 SYSTEM_CONSTANT "DEVLIB_PHYSRNGCHK_SY" "0"
 SYSTEM_CONSTANT "DEVLIB_PSOFFOPNLD_SY" "1"
 SYSTEM_CONSTANT "DEVLIB_PWRSTGSTATEMOCSOPCHK_SY" "0"
 SYSTEM_CONSTANT "DFC_CTLDISBLLAYOUT_SY" "0"
 SYSTEM_CONSTANT "DFC_CTLMSKBYTES_SY" "2"
 SYSTEM_CONSTANT "DFC_CTLMSK_RESCANCMSK" "2048"
 SYSTEM_CONSTANT "DFC_CTLMSK_RESINIMSK" "1024"
 SYSTEM_CONSTANT "DFC_DISBLMSKBYTES_SY" "2"
 SYSTEM_CONSTANT "DFES_BLKENTRY_SY" "0"
 SYSTEM_CONSTANT "DFES_COMMILDEB_SY" "0"
 SYSTEM_CONSTANT "DFES_EOBDCV_SY" "0"
 SYSTEM_CONSTANT "DFES_EOLCLR_SY" "0"
 SYSTEM_CONSTANT "DFES_EXTDFLT_SY" "0"
 SYSTEM_CONSTANT "DFES_IRV_SY" "0"
 SYSTEM_CONSTANT "DFES_MONITORING_LEN_SY" "1"
 SYSTEM_CONSTANT "DFES_NUMENTRIES_SY" "10"
 SYSTEM_CONSTANT "DFES_PDTC_SY" "0"
 SYSTEM_CONSTANT "DFES_PRVTSTRDLT_SY" "0"
 SYSTEM_CONSTANT "DFES_SIMCOND_READONLY" "1"
 SYSTEM_CONSTANT "DFES_SIMCOND_SY" "1"
 SYSTEM_CONSTANT "DIABAS_ATSTST_SY" "0"
 SYSTEM_CONSTANT "DIABAS_AVSTST_SY" "0"
 SYSTEM_CONSTANT "DIABAS_ETCTST_SY" "0"
 SYSTEM_CONSTANT "DIABAS_I15031TST_SY" "0"
 SYSTEM_CONSTANT "DIABAS_NODIAP_SY" "1"
 SYSTEM_CONSTANT "DIABAS_SIGNALSTST_SY" "0"
 SYSTEM_CONSTANT "DIAGCOM_BOOTPART_SY" "1"
 SYSTEM_CONSTANT "DIAGCOM_RDPI_SY" "0"
 SYSTEM_CONSTANT "DIAGCOM_RESPONEVT_SY" "0"
 SYSTEM_CONSTANT "DIAGCOM_RINGBUF_SY" "0"
 SYSTEM_CONSTANT "DIPO_SY" "0"
 SYSTEM_CONSTANT "DISTAB_SY" "1"
 SYSTEM_CONSTANT "DIUMPR_500MD_SY" "1"
 SYSTEM_CONSTANT "DIUMPR_NUMDENOMIDXGRP_SY" "0"
 SYSTEM_CONSTANT "DIUMPR_NUMMSGGRPS" "0"
 SYSTEM_CONSTANT "DIUMPR_NUMRATCFG" "0"
 SYSTEM_CONSTANT "DIUMPR_NUMRATCLB" "0"
 SYSTEM_CONSTANT "DIUMPR_NUMSIGCLB" "0"
 SYSTEM_CONSTANT "DIUMPR_NUM_GROUPS_SY" "0"
 SYSTEM_CONSTANT "DM_AMPTSOX_RES_FL" "0.004"
 SYSTEM_CONSTANT "DM_SOX2_RES_FL" "0.004"
 SYSTEM_CONSTANT "DPDIFFTMP_RES" "100"
 SYSTEM_CONSTANT "DPDIFF_RES" "0.1"
 SYSTEM_CONSTANT "DPRC_100" "100"
 SYSTEM_CONSTANT "DPRC_M_100" "-100"
 SYSTEM_CONSTANT "DPRC_RES_REV" "81.92"
 SYSTEM_CONSTANT "DPS_EV1E" "0"
 SYSTEM_CONSTANT "DPS_EV2E" "1"
 SYSTEM_CONSTANT "DPS_EV3E" "2"
 SYSTEM_CONSTANT "DPS_EV4E" "3"
 SYSTEM_CONSTANT "DPS_EV5E" "4"
 SYSTEM_CONSTANT "DPS_EV6E" "5"
 SYSTEM_CONSTANT "DPS_EV7E" "6"
 SYSTEM_CONSTANT "DPS_EV8E" "7"
 SYSTEM_CONSTANT "DPS_HSFE" "0"
 SYSTEM_CONSTANT "DPS_HSFE2" "3"
 SYSTEM_CONSTANT "DPS_HSHE" "1"
 SYSTEM_CONSTANT "DPS_HSHE2" "4"
 SYSTEM_CONSTANT "DPS_HSVE" "0"
 SYSTEM_CONSTANT "DPS_HSVE2" "1"
 SYSTEM_CONSTANT "DPS_HSVE2_LSF" "5"
 SYSTEM_CONSTANT "DPS_HSVE_LSF" "2"
 SYSTEM_CONSTANT "DRCTSTRT_SY" "0"
 SYSTEM_CONSTANT "DRESFLW_RES" "0.001"
 SYSTEM_CONSTANT "DRESFLW_RES_REV" "1000"
 SYSTEM_CONSTANT "DRV_T15RST_SY" "1"
 SYSTEM_CONSTANT "DSCHED_DFCSPEC_SY" "0"
 SYSTEM_CONSTANT "DSCHED_FTI_SY" "0"
 SYSTEM_CONSTANT "DSCHED_RATECALC_SY" "1"
 SYSTEM_CONSTANT "DSCHED_WTT_SY" "0"
 SYSTEM_CONSTANT "DSMAUX_READONLY" "1"
 SYSTEM_CONSTANT "DSMAUX_ROEBUFLEN" "0"
 SYSTEM_CONSTANT "DSMAUX_ROEBUFUSEENVRAM" "0"
 SYSTEM_CONSTANT "DSMAUX_TCSORT_SY" "0"
 SYSTEM_CONSTANT "DSMCONF_DFCCTTSTD" "0"
 SYSTEM_CONSTANT "DSMCONF_DTCTABLE_DTCM" "0"
 SYSTEM_CONSTANT "DSMCONF_DTCTABLE_DTCX" "0"
 SYSTEM_CONSTANT "DSMCONF_NUM_CLASSES" "22"
 SYSTEM_CONSTANT "DSMCONF_SUPGLBCTLMSK" "0"
 SYSTEM_CONSTANT "DSMCONF_SUPGLBDBLV" "1"
 SYSTEM_CONSTANT "DSMCONF_SUPGLBDISBLMSK" "0"
 SYSTEM_CONSTANT "DSMCONF_SUPGLBENVREF" "0"
 SYSTEM_CONSTANT "DSMCONF_SUPGLBFAULTTYP" "1"
 SYSTEM_CONSTANT "DSMCONF_SUPGLBFLTCLS" "0"
 SYSTEM_CONSTANT "DSMCONF_SUP_TNPSCPU" "0"
 SYSTEM_CONSTANT "DSMCONF_SUP_TNPSDTCC" "0"
 SYSTEM_CONSTANT "DSMDUR_MIL_GLB_SY" "0"
 SYSTEM_CONSTANT "DSMRDY_ENGSPEC_SY" "1"
 SYSTEM_CONSTANT "DSMRDY_ENVCOND_SUP" "0"
 SYSTEM_CONSTANT "DSMRDY_FIDINH_SUP" "0"
 SYSTEM_CONSTANT "DSMRDY_INHP41_SY" "0"
 SYSTEM_CONSTANT "DSMRDY_READONLY" "1"
 SYSTEM_CONSTANT "DSMRDY_SIZE_LST_AC" "1"
 SYSTEM_CONSTANT "DSMRDY_SIZE_LST_Cat" "1"
 SYSTEM_CONSTANT "DSMRDY_SIZE_LST_ComprCmpnt" "1"
 SYSTEM_CONSTANT "DSMRDY_SIZE_LST_EGR" "1"
 SYSTEM_CONSTANT "DSMRDY_SIZE_LST_EvpSys" "1"
 SYSTEM_CONSTANT "DSMRDY_SIZE_LST_FlSys" "1"
 SYSTEM_CONSTANT "DSMRDY_SIZE_LST_HtCat" "1"
 SYSTEM_CONSTANT "DSMRDY_SIZE_LST_Misf" "1"
 SYSTEM_CONSTANT "DSMRDY_SIZE_LST_O2Sens" "52"
 SYSTEM_CONSTANT "DSMRDY_SIZE_LST_O2SensHt" "24"
 SYSTEM_CONSTANT "DSMRDY_SIZE_LST_SecAirSys" "1"
 SYSTEM_CONSTANT "DSMRDY_SUPPID41_SY" "1"
 SYSTEM_CONSTANT "DSM_CONF_SUP_DSMRDY_CT" "0"
 SYSTEM_CONSTANT "DSM_CONF_SUP_DSMRDY_XWHY" "1"
 SYSTEM_CONSTANT "DSM_DISBLGRPSIZE_SY" "0"
 SYSTEM_CONSTANT "DSM_FAILCNT_SY" "0"
 SYSTEM_CONSTANT "DSM_FAULTSEQ_SY" "0"
 SYSTEM_CONSTANT "DSM_HDOBD_SY" "0"
 SYSTEM_CONSTANT "DSM_INHRLS_SY" "0"
 SYSTEM_CONSTANT "DSM_NUMDFC" "425"
 SYSTEM_CONSTANT "DSM_NUMFID" "61"
 SYSTEM_CONSTANT "DSM_PDTCTSTRA_SY" "1"
 SYSTEM_CONSTANT "DSM_WUCDET_SY" "1"
 SYSTEM_CONSTANT "DTR_FACTKLINE" "13"
 SYSTEM_CONSTANT "DTR_FACT_RES" "0"
 SYSTEM_CONSTANT "DTR_FACT_RES_REV" "8192"
 SYSTEM_CONSTANT "DTR_LEGIFC_SY" "0"
 SYSTEM_CONSTANT "DTTEMP_300" "300"
 SYSTEM_CONSTANT "DTTEMP_M_300" "-300"
 SYSTEM_CONSTANT "DTY_CYC_FAC" "1.95503421309873"
 SYSTEM_CONSTANT "DT_KELV_RES" "0.1"
 SYSTEM_CONSTANT "DVOL_RES" "0.1"
 SYSTEM_CONSTANT "D_FLCONS_RES" "0.01"
 SYSTEM_CONSTANT "ECBVLVTWIN_TYPAVLDIGACTRLIB_SY" "0"
 SYSTEM_CONSTANT "ECBVLV_TYPAVLDIGACTRLIB_SY" "1"
 SYSTEM_CONSTANT "ECUNUM_SY" "1"
 SYSTEM_CONSTANT "ECUOFF_TMR_SY" "0"
 SYSTEM_CONSTANT "ECU_GENR_SY" "2"
 SYSTEM_CONSTANT "ECU_TRICORE_SY" "9"
 SYSTEM_CONSTANT "EEOT_SY" "0"
 SYSTEM_CONSTANT "EFFCNY_RES" "0.001"
 SYSTEM_CONSTANT "EGTCOND_ACTV_BP" "0"
 SYSTEM_CONSTANT "EGTSWT_FACT" "16384000"
 SYSTEM_CONSTANT "EGTSWT_FACT_S16" "16384"
 SYSTEM_CONSTANT "EGTSWT_NRM_EXP" "14"
 SYSTEM_CONSTANT "EGTSWT_RES" "6.103515625e-008"
 SYSTEM_CONSTANT "EGTSWT_RES_S16" "6.103515625e-005"
 SYSTEM_CONSTANT "ENERGY_J_HI_RES" "1"
 SYSTEM_CONSTANT "ENERGY_Q0P0001_RES" "0.0001"
 SYSTEM_CONSTANT "ENERGY_Q0P0001_RES_REV" "10000"
 SYSTEM_CONSTANT "ENERGY_Q0P001_RES" "0.001"
 SYSTEM_CONSTANT "ENERGY_Q0P001_RES_REV" "1000"
 SYSTEM_CONSTANT "ENERGY_RES" "1"
 SYSTEM_CONSTANT "ENGRESTRT_SY" "0"
 SYSTEM_CONSTANT "ENGSPD_SWTENA_SY" "0"
 SYSTEM_CONSTANT "ENRGPERMASS_RES" "0.1"
 SYSTEM_CONSTANT "EPMBCA_FACSEGTIMEACC_CURX_SC" "3"
 SYSTEM_CONSTANT "EPMCAS_FACPLAUS_DSTX" "3"
 SYSTEM_CONSTANT "EPMCAS_FACPLAUS_DSTX_SC" "3"
 SYSTEM_CONSTANT "EPMCAS_NUMSEG" "10"
 SYSTEM_CONSTANT "EPMCAS_NUMSEGLEN" "10"
 SYSTEM_CONSTANT "EPMCAS_NUMSEGLEN_SC" "16"
 SYSTEM_CONSTANT "EPMCAS_NUMSEG_SC" "48"
 SYSTEM_CONSTANT "EPMCAS_PHINCOR_CURX" "6"
 SYSTEM_CONSTANT "EPMCAS_PHINCOR_CURX_SC" "6"
 SYSTEM_CONSTANT "EPMCAS_PHITEMPCOR05_DSTX" "3"
 SYSTEM_CONSTANT "EPMCAS_PHITEMPCOR05_DSTX_SC" "3"
 SYSTEM_CONSTANT "EPMCRS_NUMTHRESH" "4"
 SYSTEM_CONSTANT "EPMCRS_NUMTTMEAS" "15"
 SYSTEM_CONSTANT "EPMCRS_NUMVAL" "4"
 SYSTEM_CONSTANT "EPMCRS_REVSTRTCONT_SC" "1"
 SYSTEM_CONSTANT "EPMCRS_TIPLSFWD" "45"
 SYSTEM_CONSTANT "EPMCRS_TIPLSREV" "90"
 SYSTEM_CONSTANT "EPMHCRS_NUMGAP" "1"
 SYSTEM_CONSTANT "EPMHCRS_NUMINC" "60"
 SYSTEM_CONSTANT "EPMHCRS_NUMINCGAP" "3"
 SYSTEM_CONSTANT "EPMHWE_RTM_SY" "0"
 SYSTEM_CONSTANT "EPMHWE_SWTCPU_SY" "0"
 SYSTEM_CONSTANT "EPMRRS_NUMPER" "16"
 SYSTEM_CONSTANT "EPMRRS_SY" "0"
 SYSTEM_CONSTANT "EPMRRS_TITEMP_CURX_SC" "3"
 SYSTEM_CONSTANT "EPMRVSROTYMETH_SY" "0"
 SYSTEM_CONSTANT "EPMSYN_PHIINCCOR_CURX" "4"
 SYSTEM_CONSTANT "EPMSYN_PHIINCCOR_CURX_SC" "4"
 SYSTEM_CONSTANT "EPM_ATS_SY" "0"
 SYSTEM_CONSTANT "EPM_DIAGSPC_SY" "0"
 SYSTEM_CONSTANT "EPM_GTCRED_SY" "0"
 SYSTEM_CONSTANT "EPM_KEEPDGISYNC_SC" "0"
 SYSTEM_CONSTANT "EPM_MEASURE_SY" "2"
 SYSTEM_CONSTANT "EPM_NENG10MSMAX" "2550"
 SYSTEM_CONSTANT "EPM_NUMCRSREVWCY" "2"
 SYSTEM_CONSTANT "EPM_NUMCRSREVWCY_SY" "2"
 SYSTEM_CONSTANT "EPM_PHICRSREV" "360"
 SYSTEM_CONSTANT "EPM_PHIMAXMSK" "32767"
 SYSTEM_CONSTANT "EPM_PHIMAX_SY" "32767"
 SYSTEM_CONSTANT "EPM_SPD_CALC_SY" "0"
 SYSTEM_CONSTANT "EPM_SYNCSLV_SY" "0"
 SYSTEM_CONSTANT "EPM_TDCDSTCLB_SC" "0"
 SYSTEM_CONSTANT "EPM_TIMING_SY" "0"
 SYSTEM_CONSTANT "EPM_TI_SHORTINT" "2500"
 SYSTEM_CONSTANT "EPM_VAR_SY" "999"
 SYSTEM_CONSTANT "ESC_DT_NESTING_DEPTH" "10"
 SYSTEM_CONSTANT "ESC_MACHINE_TICKS_PER_US" "1"
 SYSTEM_CONSTANT "ETA_THM_ENG_ONE" "1"
 SYSTEM_CONSTANT "ETCLB_NUM_RAILP_CLB_PNT" "2"
 SYSTEM_CONSTANT "ETCTL_ACTV_BP" "0"
 SYSTEM_CONSTANT "ETC_Act_SY" "1"
 SYSTEM_CONSTANT "ETKS_SY" "1"
 SYSTEM_CONSTANT "ETS_INJPOI1" "4"
 SYSTEM_CONSTANT "ETS_LEAN_SY" "1"
 SYSTEM_CONSTANT "ETS_NSC_SY" "1"
 SYSTEM_CONSTANT "ETS_NUMINPMSK_SY" "7"
 SYSTEM_CONSTANT "ETS_PFLT1_SY" "1"
 SYSTEM_CONSTANT "ETS_PFLT2_1" "31"
 SYSTEM_CONSTANT "ETS_PFLT2_SY" "1"
 SYSTEM_CONSTANT "ETS_PHC_SY" "2"
 SYSTEM_CONSTANT "ETS_SOX_SY" "1"
 SYSTEM_CONSTANT "EXHFLP_TYPAVLACTRLIB_SY" "0"
 SYSTEM_CONSTANT "EXHMOD_TSPS1_SC" "0"
 SYSTEM_CONSTANT "FACT16_EXP" "16"
 SYSTEM_CONSTANT "FACT16_RES_REV" "65536"
 SYSTEM_CONSTANT "FACT1_ZERO" "0"
 SYSTEM_CONSTANT "FACT26_EXP" "26"
 SYSTEM_CONSTANT "FACT26_RES" "1.49011611938477e-008"
 SYSTEM_CONSTANT "FACT26_RES_REV" "67108864"
 SYSTEM_CONSTANT "FACT6_RES_REV" "500"
 SYSTEM_CONSTANT "FACT9_RES_REV" "5000"
 SYSTEM_CONSTANT "FACTLOW1_RES_REV" "25"
 SYSTEM_CONSTANT "FACT_NSCAGETOT_RES" "3"
 SYSTEM_CONSTANT "FACT_NSCAGE_RES" "0.001"
 SYSTEM_CONSTANT "FACT_NSCEFF_RES" "0.0001"
 SYSTEM_CONSTANT "FACT_NSCEFF_RES_REV" "10000"
 SYSTEM_CONSTANT "FACT_NSC_MAX" "1"
 SYSTEM_CONSTANT "FACT_NSC_MIN" "0"
 SYSTEM_CONSTANT "FACT_NSC_RES" "0.001"
 SYSTEM_CONSTANT "FACT_NSC_RES_REV" "1000"
 SYSTEM_CONSTANT "FACT_OIL_VOLSNGLDIFF" "32000"
 SYSTEM_CONSTANT "FACT_Q0P001_RES" "0.001"
 SYSTEM_CONSTANT "FACT_Q0P001_RES_REV" "1000"
 SYSTEM_CONSTANT "FACT_VOLNSC_RES" "1e-006"
 SYSTEM_CONSTANT "FACT_VOLNSC_RES_FL" "1e-006"
 SYSTEM_CONSTANT "FAC_AG_CRS_HI_RESO" "128"
 SYSTEM_CONSTANT "FAC_MASSINJ_TO_QNTINJ" "10000"
 SYSTEM_CONSTANT "FAC_QNTADJ_TO_QNTINJ_0" "1000"
 SYSTEM_CONSTANT "FAC_QNTADJ_TO_QNTINJ_1" "1500"
 SYSTEM_CONSTANT "FAC_QNTADJ_TO_QNTINJ_2" "2500"
 SYSTEM_CONSTANT "FAC_QNTADJ_TO_QNTINJ_3" "5000"
 SYSTEM_CONSTANT "FAC_QNTADJ_TO_QNTINJ_RES" "100"
 SYSTEM_CONSTANT "FAC_T_INC_PER_DUR_HI_RESO" "256"
 SYSTEM_CONSTANT "FADC_ADDL1_REGVAL" "0"
 SYSTEM_CONSTANT "FADC_ADDL2_REGVAL" "1"
 SYSTEM_CONSTANT "FADC_ADDL3_REGVAL" "2"
 SYSTEM_CONSTANT "FADC_ADDL4_REGVAL" "3"
 SYSTEM_CONSTANT "FADC_ADDL5_REGVAL" "4"
 SYSTEM_CONSTANT "FADC_ADDL6_REGVAL" "5"
 SYSTEM_CONSTANT "FADC_ADDL7_REGVAL" "6"
 SYSTEM_CONSTANT "FADC_ADDL8_REGVAL" "7"
 SYSTEM_CONSTANT "FADC_GN1_REGVAL" "0"
 SYSTEM_CONSTANT "FADC_GN2_REGVAL" "1"
 SYSTEM_CONSTANT "FADC_GN4_REGVAL" "2"
 SYSTEM_CONSTANT "FADC_GN8_REGVAL" "3"
 SYSTEM_CONSTANT "FADC_MAVL1_REGVAL" "0"
 SYSTEM_CONSTANT "FADC_MAVL2_REGVAL" "1"
 SYSTEM_CONSTANT "FADC_MAVL3_REGVAL" "2"
 SYSTEM_CONSTANT "FADC_MAVL4_REGVAL" "3"
 SYSTEM_CONSTANT "FANCTL_HOTLMP" "0"
 SYSTEM_CONSTANT "FANCTL_HOTLMPWRN" "1"
 SYSTEM_CONSTANT "FANCTL_VARDET_SY" "0"
 SYSTEM_CONSTANT "FAN_NUMDIGOUT_SY" "1"
 SYSTEM_CONSTANT "FEA_SY_MX17" "1"
 SYSTEM_CONSTANT "FLCONS1_RES" "0.01"
 SYSTEM_CONSTANT "FLCONS2_RES" "1"
 SYSTEM_CONSTANT "FLCONS2_RES_HIGH_REV" "20"
 SYSTEM_CONSTANT "FLCONS2_RES_REV" "1"
 SYSTEM_CONSTANT "FLCONS3_MIN" "0"
 SYSTEM_CONSTANT "FLCONS_SDET_MIN" "0.01"
 SYSTEM_CONSTANT "FLMNG_R_STOICH_CONF" "14.5"
 SYSTEM_CONSTANT "FLOWFCTCRITAIR" "0.48417899"
 SYSTEM_CONSTANT "FLVOL_RES" "0.05"
 SYSTEM_CONSTANT "FLXR_SY" "0"
 SYSTEM_CONSTANT "FMA_DT1_RES" "4294.967296"
 SYSTEM_CONSTANT "FMA_N_2_PSI" "33554.432"
 SYSTEM_CONSTANT "FMA_Q_2_PSI" "67108.864"
 SYSTEM_CONSTANT "GDI_SY" "0"
 SYSTEM_CONSTANT "GEAR0" "0"
 SYSTEM_CONSTANT "GEAR1" "1"
 SYSTEM_CONSTANT "GEAR2" "2"
 SYSTEM_CONSTANT "GEAR3" "3"
 SYSTEM_CONSTANT "GEAR4" "4"
 SYSTEM_CONSTANT "GEAR5" "5"
 SYSTEM_CONSTANT "GEAR6" "6"
 SYSTEM_CONSTANT "GEAR7" "7"
 SYSTEM_CONSTANT "GLWCTL_TIME_MS_RES" "10"
 SYSTEM_CONSTANT "GPTA_ASCSEL_SC" "0"
 SYSTEM_CONSTANT "GPTA_BSSSEL_SC" "0"
 SYSTEM_CONSTANT "GSSYS_TYPEEXHFLW_SY" "1"
 SYSTEM_CONSTANT "HCI_DISABLE_SY" "1"
 SYSTEM_CONSTANT "HCMPT_Q0P0000004_ZERO" "0"
 SYSTEM_CONSTANT "HEAT_CAPACITY_RES_REV" "10"
 SYSTEM_CONSTANT "HEGONTK_SY" "1"
 SYSTEM_CONSTANT "HEM_SY" "0"
 SYSTEM_CONSTANT "HEVTYP_SY" "0"
 SYSTEM_CONSTANT "HSHEXT_SY" "0"
 SYSTEM_CONSTANT "I14229_RDTCSEVERITY_SY" "0"
 SYSTEM_CONSTANT "I15031APPL_NUMSIZETEXHFLD_SY" "4"
 SYSTEM_CONSTANT "I15031_CUS_SY" "0"
 SYSTEM_CONSTANT "I15031_SRV8_SY" "0"
 SYSTEM_CONSTANT "I2CEMU_SY" "0"
 SYSTEM_CONSTANT "IDEAL_GAS_VOL" "22.4"
 SYSTEM_CONSTANT "IGNARCDURMONI_SY" "0"
 SYSTEM_CONSTANT "IGNARC_NUMTIM_SY" "1"
 SYSTEM_CONSTANT "IGNCLPS_BENCHERR_SC" "0"
 SYSTEM_CONSTANT "IGNCLPS_STADIAENBL_SY" "1"
 SYSTEM_CONSTANT "IGNCL_CLCRNTMON_SY" "0"
 SYSTEM_CONSTANT "IGNCL_INTCALCNXTCHL_SC" "1"
 SYSTEM_CONSTANT "IGNCL_QAG_SY" "1"
 SYSTEM_CONSTANT "IGNINCIR_SY" "1"
 SYSTEM_CONSTANT "INIT_ZERO" "0"
 SYSTEM_CONSTANT "INJCRV_ANGLE" "0"
 SYSTEM_CONSTANT "INJCRV_TIME" "1"
 SYSTEM_CONSTANT "INJGDI_NUMPRESCIR_SY" "1"
 SYSTEM_CONSTANT "INJMSQ0P1_RES" "0.1"
 SYSTEM_CONSTANT "INJMSQ0P2_RES" "0.2"
 SYSTEM_CONSTANT "INJSYS_INJRLSSETPOINT_SY" "0"
 SYSTEM_CONSTANT "INJSYS_POI1SETPOINT_SY" "0"
 SYSTEM_CONSTANT "INJSYS_POI2SETPOINT_SY" "0"
 SYSTEM_CONSTANT "INJSYS_POI3SETPOINT_SY" "0"
 SYSTEM_CONSTANT "INJTIME_US_ZERO" "0"
 SYSTEM_CONSTANT "INJVLVPS_DIASMALLTI_SY" "0"
 SYSTEM_CONSTANT "INJVLV_ADDRLY_SY" "0"
 SYSTEM_CONSTANT "INJVLV_ATS_SY" "0"
 SYSTEM_CONSTANT "INJVLV_CRNTPRFLMOD_SY" "0"
 SYSTEM_CONSTANT "INJVLV_DURVLVOFFMNST_SY" "1300"
 SYSTEM_CONSTANT "INJVLV_DURVLVOFFMN_SY" "200"
 SYSTEM_CONSTANT "INJVLV_ENDC_SY" "0"
 SYSTEM_CONSTANT "INJVLV_FSTRCVAFTFCO_SY" "0"
 SYSTEM_CONSTANT "INJ_MASS100_MAX" "100"
 SYSTEM_CONSTANT "INJ_MASSCYC_MAX" "327.67"
 SYSTEM_CONSTANT "INJ_MASSCYC_MIN" "0"
 SYSTEM_CONSTANT "INJ_MASSCYC_RES" "0.01"
 SYSTEM_CONSTANT "INJ_MASSCYC_RES_INV" "100"
 SYSTEM_CONSTANT "INJ_MASSCYC_RES_REV" "100"
 SYSTEM_CONSTANT "INJ_MASSCYC_ZERO" "0"
 SYSTEM_CONSTANT "INJ_MASSINJ_RES" "0.01"
 SYSTEM_CONSTANT "INJ_MASSMIN_MAX" "10"
 SYSTEM_CONSTANT "INJ_MASSPII1_MAX" "10"
 SYSTEM_CONSTANT "INJ_MASSPII2_MAX" "10"
 SYSTEM_CONSTANT "INJ_MASSPII3_MAX" "10"
 SYSTEM_CONSTANT "INJ_MASSPOI1_MAX" "10"
 SYSTEM_CONSTANT "INJ_MASSPOI2_MAX" "10"
 SYSTEM_CONSTANT "INJ_MASSPOI3_MAX" "10"
 SYSTEM_CONSTANT "INJ_MASS_MAX" "327.67"
 SYSTEM_CONSTANT "INJ_MASS_MIN" "0"
 SYSTEM_CONSTANT "INJ_MASS_ONE" "1"
 SYSTEM_CONSTANT "INJ_MASS_RES" "0.01"
 SYSTEM_CONSTANT "INJ_MASS_RES_INV" "100"
 SYSTEM_CONSTANT "INJ_MASS_ZERO" "0"
 SYSTEM_CONSTANT "INJ_QNTINJ_MAX" "100"
 SYSTEM_CONSTANT "INJ_QNTINJ_MIN" "0"
 SYSTEM_CONSTANT "INJ_QNTINJ_RES" "0.01"
 SYSTEM_CONSTANT "INJ_QNTINJ_ZERO" "0"
 SYSTEM_CONSTANT "INJ_QNT_RES" "0.1"
 SYSTEM_CONSTANT "IUMPR_SY" "0"
 SYSTEM_CONSTANT "IUMPR_VERS_SY" "1"
 SYSTEM_CONSTANT "I_COIL_MAX" "5000"
 SYSTEM_CONSTANT "I_COIL_MIN" "0"
 SYSTEM_CONSTANT "JUL_RES" "0.1"
 SYSTEM_CONSTANT "KD_PRAIL2Q_1_MAX" "0.5"
 SYSTEM_CONSTANT "KD_PRAIL2Q_1_NRM" "4"
 SYSTEM_CONSTANT "KD_PRC_RES" "0.000125"
 SYSTEM_CONSTANT "KGH_TO_KGS" "3600"
 SYSTEM_CONSTANT "KI_LAMCTL_RES" "0.003814697265625"
 SYSTEM_CONSTANT "KI_LAMCTL_RES_REV" "262.144"
 SYSTEM_CONSTANT "KI_PRAIL2Q_1_MAX" "2"
 SYSTEM_CONSTANT "KI_PRAIL2Q_1_NRM" "1"
 SYSTEM_CONSTANT "KP_LMBDREC2INJMASS_1_MAX" "250"
 SYSTEM_CONSTANT "KP_LMBDREC2INJMASS_1_NRM" "2"
 SYSTEM_CONSTANT "KP_LMBDREC2INJMASS_1_RES_REV" "4"
 SYSTEM_CONSTANT "KP_PRAIL2Q_1_MAX" "0.2"
 SYSTEM_CONSTANT "KP_PRAIL2Q_1_NRM" "2"
 SYSTEM_CONSTANT "L9929_SY" "0"
 SYSTEM_CONSTANT "LAMBDAREC_RESVAL" "0.001"
 SYSTEM_CONSTANT "LAMBDA_INJMASS_RES" "1450"
 SYSTEM_CONSTANT "LAMBDA_MIN" "0"
 SYSTEM_CONSTANT "LAMBDA_ONE" "1"
 SYSTEM_CONSTANT "LAMBDA_REC_ZERO" "0"
 SYSTEM_CONSTANT "LAMBDA_TEN" "10"
 SYSTEM_CONSTANT "LAMBDA_ZERO" "0"
 SYSTEM_CONSTANT "LAMCORENGTEMP_SY" "0"
 SYSTEM_CONSTANT "LAMCTLDESVAL_NUM" "2"
 SYSTEM_CONSTANT "LAMCTLGOV_NUM" "2"
 SYSTEM_CONSTANT "LAMCTLMON_DVT_MAX" "10"
 SYSTEM_CONSTANT "LAMCTLMON_NUM_RM" "2"
 SYSTEM_CONSTANT "LAMCTLMON_TIME_MAX" "20"
 SYSTEM_CONSTANT "LAMCTLPRECTL_NUM" "2"
 SYSTEM_CONSTANT "LAMCTL_ACTVMONFDBKCTL_BP" "1"
 SYSTEM_CONSTANT "LAMCTL_DFL" "0"
 SYSTEM_CONSTANT "LAMCTL_SWTACTV_BP" "0"
 SYSTEM_CONSTANT "LENGTH_M_PER_KM" "1000"
 SYSTEM_CONSTANT "LLIM_ACTIVE" "3"
 SYSTEM_CONSTANT "LLIM_OFF" "1"
 SYSTEM_CONSTANT "LLIM_STANDBY" "2"
 SYSTEM_CONSTANT "LSM_SY" "1"
 SYSTEM_CONSTANT "LSUADV_SY" "0"
 SYSTEM_CONSTANT "LSUDLYFLT_SY" "0"
 SYSTEM_CONSTANT "LSUHTRCPLMON_SY" "0"
 SYSTEM_CONSTANT "LSU_CT_SENSORS" "1"
 SYSTEM_CONSTANT "LSU_CT_SENSORS_MAX" "4"
 SYSTEM_CONSTANT "LSU_CT_SENSORS_SY" "1"
 SYSTEM_CONSTANT "LSU_CT_SENSORS_TWFLW_SYS" "2"
 SYSTEM_CONSTANT "LSU_DT1_RES" "4294.967296"
 SYSTEM_CONSTANT "MASS_CONV_G2MG" "1000"
 SYSTEM_CONSTANT "MASS_CONV_KG2G" "1000"
 SYSTEM_CONSTANT "MASS_MOL_EG" "28.5"
 SYSTEM_CONSTANT "MASS_Q1_RES_REV" "1"
 SYSTEM_CONSTANT "MAX_NUM_ADDINJ_SY" "1"
 SYSTEM_CONSTANT "MAX_NUM_MAININJ_SY" "4"
 SYSTEM_CONSTANT "MFVLV_CDRVCALCENBL_SY" "1"
 SYSTEM_CONSTANT "MFVLV_CY202_SY" "1"
 SYSTEM_CONSTANT "MILLMP_PWRSTG_SY" "0"
 SYSTEM_CONSTANT "MILLMP_SUPRT_ATS_SY" "0"
 SYSTEM_CONSTANT "MOLMASS_RES" "0.01"
 SYSTEM_CONSTANT "MO_ROOM_RES_SY" "256"
 SYSTEM_CONSTANT "MSI_SY" "0"
 SYSTEM_CONSTANT "MSI_TMPR_SY" "0"
 SYSTEM_CONSTANT "MSPERVOL_RES" "0.001"
 SYSTEM_CONSTANT "MSPERVOL_RES_REV" "1000"
 SYSTEM_CONSTANT "MS_O2_FINE_RES" "1e-005"
 SYSTEM_CONSTANT "MS_O2_FINE_RES_REV" "100000"
 SYSTEM_CONSTANT "MS_O2_RES" "0.001"
 SYSTEM_CONSTANT "MS_O2_RES_REV" "1000"
 SYSTEM_CONSTANT "MS_SOXLDTOT_RES" "0.5"
 SYSTEM_CONSTANT "MS_SOXLDTOT_RES_FL" "0.5"
 SYSTEM_CONSTANT "MS_SOXLDTOT_RES_REV" "2"
 SYSTEM_CONSTANT "MS_SOXLDUNLD_RES" "3.0517578125"
 SYSTEM_CONSTANT "MS_SOXLDUNLD_RES_FL" "3.0517578125"
 SYSTEM_CONSTANT "MS_SOXNOX_RES" "1e-005"
 SYSTEM_CONSTANT "MS_SOXNOX_RES_FL" "1e-005"
 SYSTEM_CONSTANT "MS_SOXNOX_RES_REV" "100000"
 SYSTEM_CONSTANT "MS_SOX_RES" "0.000305"
 SYSTEM_CONSTANT "M_NOXLD_LORES_RES" "0.004"
 SYSTEM_CONSTANT "M_NOXLD_LORES_RES_REV" "250"
 SYSTEM_CONSTANT "M_NOXMSSOX_RES" "0.00030517578125"
 SYSTEM_CONSTANT "M_NOXMSSOX_RES_REV" "3276.8"
 SYSTEM_CONSTANT "M_SOOT_HI_RES" "1e-007"
 SYSTEM_CONSTANT "M_SOOT_RES1" "0.004"
 SYSTEM_CONSTANT "M_SOOT_RES1_REV" "250"
 SYSTEM_CONSTANT "NORM_AIRMASS_INJCRV_FACT1" "1280"
 SYSTEM_CONSTANT "NORM_DVOLPERSTRK_X_N" "6666.66666666667"
 SYSTEM_CONSTANT "NORM_DVOL_X_DT" "360000"
 SYSTEM_CONSTANT "NORM_HCMPTQ0P00000042HCMPT" "4"
 SYSTEM_CONSTANT "NORM_HCMPTQ0P82HCMPT" "8"
 SYSTEM_CONSTANT "NORM_LMBD_RES" "0.00145"
 SYSTEM_CONSTANT "NORM_MNOXLOAD2LR" "400"
 SYSTEM_CONSTANT "NORM_Q2PWR" "10644.4551086344"
 SYSTEM_CONSTANT "NORM_Q_BY_RHO" "1000"
 SYSTEM_CONSTANT "NORM_SEC_US" "1000000"
 SYSTEM_CONSTANT "NORM_TIME2LR" "100"
 SYSTEM_CONSTANT "NORM_TRQ2PWR" "3599.99660074774"
 SYSTEM_CONSTANT "NOXFLWEG_RES" "0.025"
 SYSTEM_CONSTANT "NOXFLW_RES" "0.001"
 SYSTEM_CONSTANT "NOXMASSFLW_RES" "0.001"
 SYSTEM_CONSTANT "NOXMASSFLW_RES_REV" "1000"
 SYSTEM_CONSTANT "NOX_FLD" "10"
 SYSTEM_CONSTANT "NOX_RES" "1"
 SYSTEM_CONSTANT "NRM_DVOLPERSTRK_X_N" "6666.66666666667"
 SYSTEM_CONSTANT "NRM_DVOL_X_DT" "360000"
 SYSTEM_CONSTANT "NRM_DVOL_X_DT_HIGH" "18000"
 SYSTEM_CONSTANT "NRM_EXPO_AG_CRS_HI_RESO" "7"
 SYSTEM_CONSTANT "NRM_EXPO_T_INC_PER_DUR_HI_RESO" "8"
 SYSTEM_CONSTANT "NRM_EXP_RES_TRIGO_FUNC" "12"
 SYSTEM_CONSTANT "NRM_Q_BY_RHO" "1000"
 SYSTEM_CONSTANT "NRM_UNBALTRIM_X_N" "66666.6666666667"
 SYSTEM_CONSTANT "NRM_VOL_L_TO_UL" "20"
 SYSTEM_CONSTANT "NSCDS_CT_SENSORS" "1"
 SYSTEM_CONSTANT "NSCLD_MTOTSTRTRGN_MIN" "0.001"
 SYSTEM_CONSTANT "NSCLD_RDCAGTMIN" "-1e-005"
 SYSTEM_CONSTANT "NSCMON_TIAFTLM_MAX" "65.536"
 SYSTEM_CONSTANT "NSCMON_UBINLAM_MAX" "2000"
 SYSTEM_CONSTANT "NSCRGN_TIME_100_RES" "0.01"
 SYSTEM_CONSTANT "NSC_ACTV_BP" "1"
 SYSTEM_CONSTANT "NSC_AMPTNOXLDUNLD_MAX" "0"
 SYSTEM_CONSTANT "NSC_AMPTNOXLDUNLD_MIN" "-10"
 SYSTEM_CONSTANT "NSC_AMPTNOXRGN_MAX" "0"
 SYSTEM_CONSTANT "NSC_AMPTNOX_MIN" "0"
 SYSTEM_CONSTANT "NSC_CT_SENSORS" "2"
 SYSTEM_CONSTANT "NSC_CT_SENSORS_SY" "2"
 SYSTEM_CONSTANT "NSC_CT_SENSORS_TWFLW_SYS" "2"
 SYSTEM_CONSTANT "NSC_MSO2_FINE_MIN" "0"
 SYSTEM_CONSTANT "NSC_MSO2_MIN" "0"
 SYSTEM_CONSTANT "NSC_MSPERVOL_MIN" "0"
 SYSTEM_CONSTANT "NSC_MSSOXNOX_MAX" "0.1"
 SYSTEM_CONSTANT "NSC_MSSOXNOX_MIN" "0"
 SYSTEM_CONSTANT "NSC_NOXMASSFLW_MIN" "0"
 SYSTEM_CONSTANT "NSC_NOX_ZERO" "0"
 SYSTEM_CONSTANT "NSC_SWTACTV_BP" "0"
 SYSTEM_CONSTANT "NSC_TIMEMAX_SY" "327.5"
 SYSTEM_CONSTANT "NUMCASMAX" "4"
 SYSTEM_CONSTANT "NUMCYLACT_SY" "8"
 SYSTEM_CONSTANT "NUMCYLCAL_SY" "1"
 SYSTEM_CONSTANT "NUMCYLMAX_SY" "8"
 SYSTEM_CONSTANT "NUMFANS_SY" "0"
 SYSTEM_CONSTANT "NUMPSICBNK_SY" "2"
 SYSTEM_CONSTANT "NUMPSICCHP_SY" "1"
 SYSTEM_CONSTANT "NUM_CHIP" "1"
 SYSTEM_CONSTANT "O2MPT_RES_REV" "100"
 SYSTEM_CONSTANT "O2_RES" "1e-005"
 SYSTEM_CONSTANT "OBD_PHYSMEDM_SY" "1"
 SYSTEM_CONSTANT "OBS_SY" "1"
 SYSTEM_CONSTANT "OILLVL_MMQ0P004_RES" "0.004"
 SYSTEM_CONSTANT "OILLVL_MMQ0P004_RESREV" "250"
 SYSTEM_CONSTANT "OILMFL_MGPS_Q0P1_RES" "0.1"
 SYSTEM_CONSTANT "OILMFL_MGPS_Q0P1_RES_REV" "10"
 SYSTEM_CONSTANT "OILMSPRCQ0P01_100" "100"
 SYSTEM_CONSTANT "OILMSPRC_Q0P01_RES" "0.01"
 SYSTEM_CONSTANT "OILMSPRC_Q0P01_RES_REV" "100"
 SYSTEM_CONSTANT "OILMS_MG_RES" "1"
 SYSTEM_CONSTANT "OILMS_MG_RES_REV" "1"
 SYSTEM_CONSTANT "OILMS_Q0P1_RES" "0.1"
 SYSTEM_CONSTANT "OILMS_Q0P1_RES_REV" "10"
 SYSTEM_CONSTANT "OILMS_Q10_RES" "10"
 SYSTEM_CONSTANT "ONE_FACT26" "1"
 SYSTEM_CONSTANT "OSTYPE_SY" "0"
 SYSTEM_CONSTANT "OXSENSDYNADAP_SY" "0"
 SYSTEM_CONSTANT "PCA8565_SY" "0"
 SYSTEM_CONSTANT "PCP_SY" "1"
 SYSTEM_CONSTANT "PCSI_SY" "0"
 SYSTEM_CONSTANT "PERMSPLYSYS_SY" "0"
 SYSTEM_CONSTANT "PFLTLD_RO2EG" "0.2315"
 SYSTEM_CONSTANT "PFLTLD_RO2EGONE" "1"
 SYSTEM_CONSTANT "PFLTLD_RO2STOICH" "0.2315"
 SYSTEM_CONSTANT "PFLTLD_RO2STOICHONE" "1"
 SYSTEM_CONSTANT "PFLTPOPPRC_RES" "0.1"
 SYSTEM_CONSTANT "PFLT_ACTV_BP" "0"
 SYSTEM_CONSTANT "PHASE_DETECT_SY" "0"
 SYSTEM_CONSTANT "PHI_COR_MAX" "10"
 SYSTEM_CONSTANT "PHI_MI_EARL" "40"
 SYSTEM_CONSTANT "PHI_MI_LATE" "-10"
 SYSTEM_CONSTANT "PHI_PII_EARL_ABS" "100"
 SYSTEM_CONSTANT "PHI_PII_EARL_REL" "90"
 SYSTEM_CONSTANT "PHI_PII_LATE_REL" "5"
 SYSTEM_CONSTANT "PHI_POI1_EARL" "-40"
 SYSTEM_CONSTANT "PHI_POI1_LATE" "-100"
 SYSTEM_CONSTANT "PHI_POI1_ZERO" "0"
 SYSTEM_CONSTANT "PHI_POI2_LATE" "-40"
 SYSTEM_CONSTANT "PHI_ZERO" "0"
 SYSTEM_CONSTANT "PI" "3.14159265359"
 SYSTEM_CONSTANT "PIICLB_ANGLE32FAC2ANGLE_CNV" "6553600"
 SYSTEM_CONSTANT "PIICLB_ANGLECRSS32_RES" "2982616.17777705"
 SYSTEM_CONSTANT "PIICLB_ANGLECRSS32_ZERO" "0"
 SYSTEM_CONSTANT "PIICLB_FACTS32_RES" "65536"
 SYSTEM_CONSTANT "PIICLB_INJMASSS32_RES" "6553600"
 SYSTEM_CONSTANT "PIICLB_INJMASSS32_ZERO" "0"
 SYSTEM_CONSTANT "PIICLB_QNT32FAC2ANGLE32_CNV" "144000.000000035"
 SYSTEM_CONSTANT "PIICLB_RCNFDMAX" "32766"
 SYSTEM_CONSTANT "PIICLB_STATE_CALC" "2"
 SYSTEM_CONSTANT "PIICLB_STATE_CLB" "1"
 SYSTEM_CONSTANT "PIICLB_STATE_INIT" "255"
 SYSTEM_CONSTANT "PIICLB_STATE_START" "0"
 SYSTEM_CONSTANT "PIICLB_STRLS_DISABLED" "1"
 SYSTEM_CONSTANT "PIICLB_STRLS_RELEASED" "0"
 SYSTEM_CONSTANT "PIICLB_TRQBYETA2QNT32_CNV" "83886080"
 SYSTEM_CONSTANT "PIICLB_TRQDT1KDDIV" "42949.67296"
 SYSTEM_CONSTANT "PIICLB_TRQDT1KDMUL" "65536000"
 SYSTEM_CONSTANT "PIICLB_TRQPERSEC_RES" "1000"
 SYSTEM_CONSTANT "PIICLB_UPDT_COL" "1"
 SYSTEM_CONSTANT "PIICLB_UPDT_SEQ" "0"
 SYSTEM_CONSTANT "PIICLB_VARIANT_NONE" "0"
 SYSTEM_CONSTANT "PIICLB_VARIANT_PIC" "1"
 SYSTEM_CONSTANT "PIICLB_VARIANT_PICALL" "2"
 SYSTEM_CONSTANT "PMAXCTL_FACKPNRM8" "8"
 SYSTEM_CONSTANT "PMP_QNT_MAX" "1500"
 SYSTEM_CONSTANT "PMP_QNT_RES" "0.1"
 SYSTEM_CONSTANT "PMP_QNT_ZERO" "0"
 SYSTEM_CONSTANT "POSMCCTL_FACKDNRM4" "4"
 SYSTEM_CONSTANT "POSMCCTL_FACKINRM2" "2"
 SYSTEM_CONSTANT "POSMCCTL_FACKPNRM32" "32"
 SYSTEM_CONSTANT "POSTDRV_NOMAXTI_SY" "0"
 SYSTEM_CONSTANT "POSTDRV_SOFTRST_SY" "0"
 SYSTEM_CONSTANT "POSTDRV_T15RST_SY" "1"
 SYSTEM_CONSTANT "PRCFACT100_FULLNEG" "-100"
 SYSTEM_CONSTANT "PRCFACT100_FULLPOS" "100"
 SYSTEM_CONSTANT "PRCFACT100_ZERO" "0"
 SYSTEM_CONSTANT "PRC_M_100" "-100"
 SYSTEM_CONSTANT "PREDRV_T15RST_SY" "1"
 SYSTEM_CONSTANT "PREFSCALE_RES" "1000"
 SYSTEM_CONSTANT "PRES_AIR_MAX" "3500"
 SYSTEM_CONSTANT "PRES_AIR_MIN" "0"
 SYSTEM_CONSTANT "PRES_BAR_RES" "1"
 SYSTEM_CONSTANT "PRES_HPA_2000" "2000"
 SYSTEM_CONSTANT "PRES_RAIL_GRADHI_TO_VAL" "60"
 SYSTEM_CONSTANT "PRES_RAIL_GRAD_TO_VAL" "4"
 SYSTEM_CONSTANT "PRES_RAIL_RES" "100"
 SYSTEM_CONSTANT "PRES_RAIL_RES_REV" "100"
 SYSTEM_CONSTANT "PRES_TIME_RES" "400"
 SYSTEM_CONSTANT "PRES_TIME_RES_REV" "400"
 SYSTEM_CONSTANT "PS_NUMSENS_SY" "0"
 SYSTEM_CONSTANT "PWRSQ_TEMPSQQ0P01_RES" "0.01"
 SYSTEM_CONSTANT "PWR_HIGH_RES_REV" "10"
 SYSTEM_CONSTANT "PWR_KW_RES" "0.01"
 SYSTEM_CONSTANT "PWR_Q1_RES" "1"
 SYSTEM_CONSTANT "PWR_Q50_RES" "50"
 SYSTEM_CONSTANT "PWR_TEMPQ0P001_RES" "0.01"
 SYSTEM_CONSTANT "PWR_TEMPQ0P1_RES" "0.1"
 SYSTEM_CONSTANT "PWR_ZERO" "0"
 SYSTEM_CONSTANT "QNTR_EXP" "10"
 SYSTEM_CONSTANT "QNTR_MAX" "24"
 SYSTEM_CONSTANT "QNTR_MIN" "0.0009765625"
 SYSTEM_CONSTANT "QNTR_RES" "0.0009765625"
 SYSTEM_CONSTANT "QNTR_RES_REV" "1024"
 SYSTEM_CONSTANT "QNTSEL_SY" "0"
 SYSTEM_CONSTANT "Qp_RES" "10"
 SYSTEM_CONSTANT "R2S2_SY" "3"
 SYSTEM_CONSTANT "RAIL_MEUN" "1"
 SYSTEM_CONSTANT "RAIL_PCV" "0"
 SYSTEM_CONSTANT "RAIL_PRES_ZERO" "0"
 SYSTEM_CONSTANT "RATAM_RES" "0.01"
 SYSTEM_CONSTANT "RATAM_RES_HIGH" "0.001"
 SYSTEM_CONSTANT "RATAM_RES_REV" "100"
 SYSTEM_CONSTANT "RATAM_RES_REV_HIGH" "1000"
 SYSTEM_CONSTANT "RATCM_RES" "1e-006"
 SYSTEM_CONSTANT "RATNOXM_RES_FL" "1e-007"
 SYSTEM_CONSTANT "RATPCRITAIR" "0.52828199"
 SYSTEM_CONSTANT "RATSOXM_RES_FL" "1e-008"
 SYSTEM_CONSTANT "RAT_AIR_PRES_RES" "0.001"
 SYSTEM_CONSTANT "RAT_HIGH_RES" "0.001"
 SYSTEM_CONSTANT "RAT_HIGH_RES_REV" "1000"
 SYSTEM_CONSTANT "RAT_HIRES_CPP" "0.0001"
 SYSTEM_CONSTANT "RAT_HIRES_CPP_REV" "10000"
 SYSTEM_CONSTANT "RESIST_RES" "0.1"
 SYSTEM_CONSTANT "RESO_T_INC_PER_DUR_TTH_ADAP" "10"
 SYSTEM_CONSTANT "REVCNT_RES" "16"
 SYSTEM_CONSTANT "REVCNT_RES_EXP" "4"
 SYSTEM_CONSTANT "REVGEAR1" "-1"
 SYSTEM_CONSTANT "RHO_FUEL_RES" "0.1"
 SYSTEM_CONSTANT "RMPSQRVLG_S_1000_REF" "1000"
 SYSTEM_CONSTANT "RMPSQRVLG_S_100_REF" "100"
 SYSTEM_CONSTANT "RMPSQRVLG_S_REF" "1000"
 SYSTEM_CONSTANT "RMPSQRVLG_S_RES" "65536"
 SYSTEM_CONSTANT "RNOX_ZERO" "0"
 SYSTEM_CONSTANT "R_COIL_MAX" "5000"
 SYSTEM_CONSTANT "R_COIL_MIN" "0"
 SYSTEM_CONSTANT "R_RES" "1"
 SYSTEM_CONSTANT "SCALEFACDIV_RES" "200"
 SYSTEM_CONSTANT "SCR_AMPERE_RES_REV" "5"
 SYSTEM_CONSTANT "SCR_DISABLE_SY" "1"
 SYSTEM_CONSTANT "SCR_DM01_RES_FL" "0.1"
 SYSTEM_CONSTANT "SCR_DTTEMP_RES" "0.1"
 SYSTEM_CONSTANT "SCR_DTTEMP_RES_REV" "10"
 SYSTEM_CONSTANT "SCR_FLVOL_RES_REV" "20"
 SYSTEM_CONSTANT "SCR_KPA100_COMP_RES_REV" "1000"
 SYSTEM_CONSTANT "SCR_KPA10_COMP_RES_REV" "100"
 SYSTEM_CONSTANT "SCR_KPA_100_RES_REV" "0.01"
 SYSTEM_CONSTANT "SCR_KPA_10_RES_REV" "0.1"
 SYSTEM_CONSTANT "SCR_NOXFLW_RES_REV" "1000"
 SYSTEM_CONSTANT "SCR_ONEMIOPPMNOX_SY" "1000000"
 SYSTEM_CONSTANT "SCR_PRCINT_COMP_RES_REV" "8192"
 SYSTEM_CONSTANT "SCR_PRES_HPA_RES_REV" "1"
 SYSTEM_CONSTANT "SCR_RAIRCTLSLP_COMP_RES_REV" "100000000"
 SYSTEM_CONSTANT "SCR_REGRVLVSLP_COMP_RES_REV" "1000"
 SYSTEM_CONSTANT "SCR_UC_VOLT_RES_REV" "10"
 SYSTEM_CONSTANT "SCR_VOLTQ0P0001227_RES" "0.0001220703125"
 SYSTEM_CONSTANT "SCR_VOLTQ0P1_RES" "0.1"
 SYSTEM_CONSTANT "SCR_VOLTQ0P1_RES_REV" "10"
 SYSTEM_CONSTANT "SCR_VOLT_Q0P002_RES_REV" "500"
 SYSTEM_CONSTANT "SEC_RES" "1"
 SYSTEM_CONSTANT "SHFTR_SY" "0"
 SYSTEM_CONSTANT "Signals_Mode1PidSize_SY" "25"
 SYSTEM_CONSTANT "Signals_NumberPID_SY" "17"
 SYSTEM_CONSTANT "Signals_NumberSigNumExt_SY" "4"
 SYSTEM_CONSTANT "Signals_NumberSigNumIntStd_SY" "36"
 SYSTEM_CONSTANT "Signals_NumberSigNumInt_SY" "36"
 SYSTEM_CONSTANT "Sig_I15031_LeanAppl_SY" "0"
 SYSTEM_CONSTANT "SOTMASSPERSEC_RES" "0.1"
 SYSTEM_CONSTANT "SOTMASSPERSEC_RES_REV" "10"
 SYSTEM_CONSTANT "SPAVEL_RES" "10"
 SYSTEM_CONSTANT "SPECHEATFINE_RES_REV" "5"
 SYSTEM_CONSTANT "SPECHEAT_RES" "2"
 SYSTEM_CONSTANT "SPECIFICHEAT_RES" "0.0001"
 SYSTEM_CONSTANT "SPECIFICHEAT_RES_REV" "10000"
 SYSTEM_CONSTANT "SSWTS_TYPE_DATASET" "2"
 SYSTEM_CONSTANT "SSWTS_TYPE_EEP" "1"
 SYSTEM_CONSTANT "STM_SY" "1"
 SYSTEM_CONSTANT "STRTTRQ_OFF" "0"
 SYSTEM_CONSTANT "STRTTRQ_ON" "1"
 SYSTEM_CONSTANT "STSP_SY" "0"
 SYSTEM_CONSTANT "SVS_SY" "0"
 SYSTEM_CONSTANT "SWT_DISABLED" "0"
 SYSTEM_CONSTANT "SWT_ENABLED" "1"
 SYSTEM_CONSTANT "SYC_FSTSWOFF_SY" "0"
 SYSTEM_CONSTANT "SYC_T15POSTPREDRV_SWRST_SY" "0"
 SYSTEM_CONSTANT "SYC_T15RSTSIM_SY" "0"
 SYSTEM_CONSTANT "SYC_UNLIMNWM_SY" "0"
 SYSTEM_CONSTANT "SYC_WREEPBLK_SY" "0"
 SYSTEM_CONSTANT "SY_2HDP2" "1"
 SYSTEM_CONSTANT "SY_AAV" "1"
 SYSTEM_CONSTANT "SY_ABGYVBP" "0"
 SYSTEM_CONSTANT "SY_ABMZND" "1"
 SYSTEM_CONSTANT "SY_AGR" "1"
 SYSTEM_CONSTANT "SY_AHRLSU" "0"
 SYSTEM_CONSTANT "SY_AIRBAG" "0"
 SYSTEM_CONSTANT "SY_ATLB" "0"
 SYSTEM_CONSTANT "SY_ATURB" "1"
 SYSTEM_CONSTANT "SY_AUFLAD" "1"
 SYSTEM_CONSTANT "SY_AUFLAD2" "1"
 SYSTEM_CONSTANT "SY_BATTSG" "0"
 SYSTEM_CONSTANT "SY_BDE" "1"
 SYSTEM_CONSTANT "SY_BUKLSU" "0"
 SYSTEM_CONSTANT "SY_CJ125" "2"
 SYSTEM_CONSTANT "SY_CJ840" "1"
 SYSTEM_CONSTANT "SY_CJ841" "2"
 SYSTEM_CONSTANT "SY_CJ870" "1"
 SYSTEM_CONSTANT "SY_CK200" "2"
 SYSTEM_CONSTANT "SY_CK200LS" "1"
 SYSTEM_CONSTANT "SY_CK200MO" "0"
 SYSTEM_CONSTANT "SY_CK240" "0"
 SYSTEM_CONSTANT "SY_CNG" "0"
 SYSTEM_CONSTANT "SY_DAPRID" "3"
 SYSTEM_CONSTANT "SY_DFPMVAR" "50"
 SYSTEM_CONSTANT "SY_DHDEVOE" "0"
 SYSTEM_CONSTANT "SY_DIONDE" "1"
 SYSTEM_CONSTANT "SY_DMDTAL" "0"
 SYSTEM_CONSTANT "SY_DMDZAG" "0"
 SYSTEM_CONSTANT "SY_DOPZW" "0"
 SYSTEM_CONSTANT "SY_DSLSZP" "0"
 SYSTEM_CONSTANT "SY_DSPACE" "0"
 SYSTEM_CONSTANT "SY_DSS" "1"
 SYSTEM_CONSTANT "SY_DSU" "1"
 SYSTEM_CONSTANT "SY_DYLSEVAL" "0"
 SYSTEM_CONSTANT "SY_EGAS" "1"
 SYSTEM_CONSTANT "SY_EKPRMK" "0"
 SYSTEM_CONSTANT "SY_ESDFPMN" "350"
 SYSTEM_CONSTANT "SY_EXCWM" "1"
 SYSTEM_CONSTANT "SY_FABE" "1"
 SYSTEM_CONSTANT "SY_FFV" "0"
 SYSTEM_CONSTANT "SY_FFZ" "1"
 SYSTEM_CONSTANT "SY_FKAT2" "1"
 SYSTEM_CONSTANT "SY_FLOAKT" "0"
 SYSTEM_CONSTANT "SY_FSSZPA" "0"
 SYSTEM_CONSTANT "SY_FTIV" "0"
 SYSTEM_CONSTANT "SY_FZEATK" "0"
 SYSTEM_CONSTANT "SY_GRDWOF" "48"
 SYSTEM_CONSTANT "SY_GRDWRT" "108"
 SYSTEM_CONSTANT "SY_GRDWRTB" "0"
 SYSTEM_CONSTANT "SY_GRDWRTC" "54"
 SYSTEM_CONSTANT "SY_H2COFK" "0"
 SYSTEM_CONSTANT "SY_H2COHK" "0"
 SYSTEM_CONSTANT "SY_HDRFREQ" "0"
 SYSTEM_CONSTANT "SY_HDST" "0"
 SYSTEM_CONSTANT "SY_HEV" "0"
 SYSTEM_CONSTANT "SY_HFM" "1"
 SYSTEM_CONSTANT "SY_HLSFFET" "0"
 SYSTEM_CONSTANT "SY_HLSHFET" "0"
 SYSTEM_CONSTANT "SY_HLSVFET" "0"
 SYSTEM_CONSTANT "SY_HMB" "0"
 SYSTEM_CONSTANT "SY_HMM" "0"
 SYSTEM_CONSTANT "SY_ICLSUIP" "1"
 SYSTEM_CONSTANT "SY_IGICCH1" "0"
 SYSTEM_CONSTANT "SY_IGICCH10" "0"
 SYSTEM_CONSTANT "SY_IGICCH11" "0"
 SYSTEM_CONSTANT "SY_IGICCH12" "0"
 SYSTEM_CONSTANT "SY_IGICCH2" "0"
 SYSTEM_CONSTANT "SY_IGICCH3" "0"
 SYSTEM_CONSTANT "SY_IGICCH4" "0"
 SYSTEM_CONSTANT "SY_IGICCH5" "1"
 SYSTEM_CONSTANT "SY_IGICCH6" "1"
 SYSTEM_CONSTANT "SY_IGICCH7" "1"
 SYSTEM_CONSTANT "SY_IGICCH8" "1"
 SYSTEM_CONSTANT "SY_IGICCH9" "0"
 SYSTEM_CONSTANT "SY_IGIFLAG" "1"
 SYSTEM_CONSTANT "SY_IGNCHN1" "0"
 SYSTEM_CONSTANT "SY_IGNCHN10" "0"
 SYSTEM_CONSTANT "SY_IGNCHN11" "0"
 SYSTEM_CONSTANT "SY_IGNCHN12" "0"
 SYSTEM_CONSTANT "SY_IGNCHN2" "1"
 SYSTEM_CONSTANT "SY_IGNCHN3" "2"
 SYSTEM_CONSTANT "SY_IGNCHN4" "3"
 SYSTEM_CONSTANT "SY_IGNCHN5" "0"
 SYSTEM_CONSTANT "SY_IGNCHN6" "1"
 SYSTEM_CONSTANT "SY_IGNCHN7" "2"
 SYSTEM_CONSTANT "SY_IGNCHN8" "3"
 SYSTEM_CONSTANT "SY_IGNCHN9" "0"
 SYSTEM_CONSTANT "SY_IUMPR" "0"
 SYSTEM_CONSTANT "SY_KS1" "0"
 SYSTEM_CONSTANT "SY_KS2" "1"
 SYSTEM_CONSTANT "SY_KS3" "2"
 SYSTEM_CONSTANT "SY_KS4" "3"
 SYSTEM_CONSTANT "SY_KSENCHN" "1"
 SYSTEM_CONSTANT "SY_KSENFLT" "10"
 SYSTEM_CONSTANT "SY_KSZA" "4"
 SYSTEM_CONSTANT "SY_KT" "0"
 SYSTEM_CONSTANT "SY_KTIGNBI" "1"
 SYSTEM_CONSTANT "SY_LSFHV" "1"
 SYSTEM_CONSTANT "SY_LSFSTA" "0"
 SYSTEM_CONSTANT "SY_LSFV" "1"
 SYSTEM_CONSTANT "SY_LSHSTA" "0"
 SYSTEM_CONSTANT "SY_LSHV" "1"
 SYSTEM_CONSTANT "SY_LSUGR" "1"
 SYSTEM_CONSTANT "SY_LSUIKR" "1"
 SYSTEM_CONSTANT "SY_LSUIKR2" "1"
 SYSTEM_CONSTANT "SY_LSUMRS" "0"
 SYSTEM_CONSTANT "SY_LSUSTA" "1"
 SYSTEM_CONSTANT "SY_LSVSTA" "0"
 SYSTEM_CONSTANT "SY_LSVV" "0"
 SYSTEM_CONSTANT "SY_LUSRKR" "0"
 SYSTEM_CONSTANT "SY_MDI" "1"
 SYSTEM_CONSTANT "SY_MSVKOMP" "2"
 SYSTEM_CONSTANT "SY_MSVRCUR" "0"
 SYSTEM_CONSTANT "SY_MXAVM" "0"
 SYSTEM_CONSTANT "SY_NG" "0"
 SYSTEM_CONSTANT "SY_NLZOFF" "0"
 SYSTEM_CONSTANT "SY_NWGA" "0"
 SYSTEM_CONSTANT "SY_NWGA2" "0"
 SYSTEM_CONSTANT "SY_NWGE" "0"
 SYSTEM_CONSTANT "SY_NWGE2" "0"
 SYSTEM_CONSTANT "SY_NWMSV" "0"
 SYSTEM_CONSTANT "SY_NWS" "0"
 SYSTEM_CONSTANT "SY_NWSA" "0"
 SYSTEM_CONSTANT "SY_PID41" "0"
 SYSTEM_CONSTANT "SY_PSTDRST" "0"
 SYSTEM_CONSTANT "SY_RHMLS" "0"
 SYSTEM_CONSTANT "SY_SALSU" "0"
 SYSTEM_CONSTANT "SY_SCH" "0"
 SYSTEM_CONSTANT "SY_SGANZ" "1"
 SYSTEM_CONSTANT "SY_SLS" "1"
 SYSTEM_CONSTANT "SY_STA" "0"
 SYSTEM_CONSTANT "SY_STASTO" "0"
 SYSTEM_CONSTANT "SY_STERHK" "1"
 SYSTEM_CONSTANT "SY_STERSY" "1"
 SYSTEM_CONSTANT "SY_STERVK" "1"
 SYSTEM_CONSTANT "SY_SU4ST" "0"
 SYSTEM_CONSTANT "SY_SVBB" "1"
 SYSTEM_CONSTANT "SY_TMMSV" "0"
 SYSTEM_CONSTANT "SY_TMSV" "0"
 SYSTEM_CONSTANT "SY_TPEACNR" "0"
 SYSTEM_CONSTANT "SY_TSPHK" "0"
 SYSTEM_CONSTANT "SY_TUMG" "3"
 SYSTEM_CONSTANT "SY_WMAX" "78"
 SYSTEM_CONSTANT "SY_WMIN" "-72"
 SYSTEM_CONSTANT "SY_WNWADM" "0"
 SYSTEM_CONSTANT "SY_WPHN" "0"
 SYSTEM_CONSTANT "SY_ZGST" "0"
 SYSTEM_CONSTANT "SY_ZNDAUS" "1"
 SYSTEM_CONSTANT "SY_ZYLOFFH" "4"
 SYSTEM_CONSTANT "SY_ZYLOFFS" "0"
 SYSTEM_CONSTANT "SY_ZYLZA" "8"
 SYSTEM_CONSTANT "SY_ZYLZG" "8"
 SYSTEM_CONSTANT "SY_ZZBANK" "210"
 SYSTEM_CONSTANT "T15_ATS_SY" "0"
 SYSTEM_CONSTANT "TDC_ADAP_SY" "0"
 SYSTEM_CONSTANT "TDC_UNEQLGEOM_SY" "0"
 SYSTEM_CONSTANT "TEGMOD_HEATFLOWKW_RES" "100000"
 SYSTEM_CONSTANT "TEGMOD_HEATFLOW_INTER_RES" "360"
 SYSTEM_CONSTANT "TEGMOD_HEATKJ_RES" "100"
 SYSTEM_CONSTANT "TEGMOD_INTER_RES" "1"
 SYSTEM_CONSTANT "TEMP_20_CELS" "20"
 SYSTEM_CONSTANT "TEMP_CELS_1200" "1200"
 SYSTEM_CONSTANT "TEMP_CELS_150" "150"
 SYSTEM_CONSTANT "TEMP_CELS_1500" "1500"
 SYSTEM_CONSTANT "TEMP_CELS_M_100" "-100"
 SYSTEM_CONSTANT "TEMP_CELS_M_200" "-200"
 SYSTEM_CONSTANT "TEMP_KELV_1000" "1000"
 SYSTEM_CONSTANT "TEMP_KELV_1200" "1200"
 SYSTEM_CONSTANT "TEMP_KELV_M_1000" "-1000"
 SYSTEM_CONSTANT "TEMP_KELV_M_200" "-200"
 SYSTEM_CONSTANT "THMPMP_TYPAVLACTRLIB_SY" "0"
 SYSTEM_CONSTANT "TIMEDELAY_S_2_MIN" "0.001"
 SYSTEM_CONSTANT "TIMEDELAY_S_2_NRM" "8"
 SYSTEM_CONSTANT "TIME_5S_NRM_SY" "5"
 SYSTEM_CONSTANT "TIME_DEB_10MS" "10000"
 SYSTEM_CONSTANT "TIME_DT_100MS" "100000"
 SYSTEM_CONSTANT "TIME_DT_1MS" "1000"
 SYSTEM_CONSTANT "TIME_DT_1S" "1000000"
 SYSTEM_CONSTANT "TIME_DT_200MS" "200000"
 SYSTEM_CONSTANT "TIME_DT_20MS" "20000"
 SYSTEM_CONSTANT "TIME_MS_MAXS32" "214748364.7"
 SYSTEM_CONSTANT "TIME_RMP_RES" "53687091.2"
 SYSTEM_CONSTANT "TIME_S_12000" "12000"
 SYSTEM_CONSTANT "TIME_S_LORES_ONE" "1"
 SYSTEM_CONSTANT "Time_s_LORES_RES" "1"
 SYSTEM_CONSTANT "Time_s_LORES_RES_REV" "1"
 SYSTEM_CONSTANT "TIME_S_LORES_ZERO" "0"
 SYSTEM_CONSTANT "TIME_S_NSCRGN_MAX" "327.66"
 SYSTEM_CONSTANT "TIME_TICK_SEC_INV" "100"
 SYSTEM_CONSTANT "TI_PII_EARL_REL" "13000"
 SYSTEM_CONSTANT "TI_POI2_LATE_REL" "-13000"
 SYSTEM_CONSTANT "TLE6232_SY" "0"
 SYSTEM_CONSTANT "TLE7209_SY" "0"
 SYSTEM_CONSTANT "TLE8209_SY" "3"
 SYSTEM_CONSTANT "TPROT_FINGERPRINT_SY" "0"
 SYSTEM_CONSTANT "TQRESL_SC" "0"
 SYSTEM_CONSTANT "TRA_AST" "2"
 SYSTEM_CONSTANT "TRA_AT" "1"
 SYSTEM_CONSTANT "TRA_CVT" "3"
 SYSTEM_CONSTANT "TRA_DCT" "4"
 SYSTEM_CONSTANT "TRA_MT" "0"
 SYSTEM_CONSTANT "TRBCHCMPR_TYPAVLACTRLIB_SY" "0"
 SYSTEM_CONSTANT "TRBCHLP_TYPAVLACTRLIB_SY" "0"
 SYSTEM_CONSTANT "TRBNBYVLV_TYPAVLACTRLIB_SY" "0"
 SYSTEM_CONSTANT "TRQSEL_SY" "1"
 SYSTEM_CONSTANT "TRQ_ENGINTV_SY" "1"
 SYSTEM_CONSTANT "TWCCBALUP_SY" "1"
 SYSTEM_CONSTANT "TWCOR_HIRES_SC" "0"
 SYSTEM_CONSTANT "TWO_POW_NRM_EXP_RES_TRIGO_FUNC" "4096"
 SYSTEM_CONSTANT "T_EXHGS_MAX" "1050"
 SYSTEM_CONSTANT "T_EXHGS_MIN" "-45"
 SYSTEM_CONSTANT "UEGO_MEASONEMSEC_SY" "1"
 SYSTEM_CONSTANT "UEGO_SEPUBATTTHDRIDIAG_SC" "0"
 SYSTEM_CONSTANT "UPMPREFL_TYPAVLACTRLIB_SY" "0"
 SYSTEM_CONSTANT "VEL_KMH_0" "0"
 SYSTEM_CONSTANT "VEL_KMH_300" "300"
 SYSTEM_CONSTANT "VEL_KMH_M_300" "-300"
 SYSTEM_CONSTANT "VFG_SC" "0"
 SYSTEM_CONSTANT "VOL_FILGLVL_RES" "1"
 SYSTEM_CONSTANT "VOL_FILGLVL_RES_REV" "1"
 SYSTEM_CONSTANT "VOL_NSC_RES" "0.0001"
 SYSTEM_CONSTANT "VOL_NSC_RES_FL" "0.0001"
 SYSTEM_CONSTANT "VOL_NSC_RES_REV" "10000"
 SYSTEM_CONSTANT "V_CAM_RES_REV" "256"
 SYSTEM_CONSTANT "XCP_SY" "1"
 SYSTEM_CONSTANT "XDI_SC" "0"
 SYSTEM_CONSTANT "ZERO" "0" /end MOD_PAR
/begin MOD_COMMON "" BYTE_ORDER MSB_LAST ALIGNMENT_BYTE 1 ALIGNMENT_WORD 2 ALIGNMENT_LONG 4 ALIGNMENT_FLOAT32_IEEE 4 /end MOD_COMMON
/* End: Example for Compu Method Referencing to table */
/end MODULE
/end PROJECT
